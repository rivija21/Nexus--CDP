options:
  parameters:
    author: Rivija Pesara (framing from Barry Duggan BPSK example)
    catch_exceptions: 'False'
    description: 'Four-node shared-channel BPSK link: CSMA/CA medium access, per-peer ARQ, browser chat (r6b)'
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: bpsk_csma_pluto
    output_language: python
    title: BPSK CSMA Chat Node (shared channel, TDD)
  states: {}

blocks:
- name: ack_timeout
  id: variable
  parameters:
    comment: seconds before retransmit
    value: '0.5'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: frag_size
  id: variable
  parameters:
    comment: payload bytes per frame
    value: '256'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: max_retries
  id: variable
  parameters:
    value: '5'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    comment: symbols of unmodulated run-in
    value: '384'
  states: {}
- name: queue_ahead
  id: variable
  parameters:
    comment: 0 = no filler; mandatory under CSMA
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'manual, not AGC: AGC would ride our own TX leakage'
    label: Rx Gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    comment: 'NOTE: attenuation, lower = more power'
    label: Tx Attenuation (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: drives ARQ timers and the TX filler
    msg: pmt.intern("tick")
    period: '10'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_post
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_pre
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: preamble | PHY header | frame | postamble
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: threshold = bit errors tolerated in the 64-bit access code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 3.14/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(constel.points())
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: tracks XO offset between the two Plutos
    filter_size: '44'
    improved_loop_filter: 'False'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: '0.03'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '1000000'
    buffer_size: '8192'
    comment: 'burst mode: len_tag_key set, so the sink flushes on the packet boundary instead of waiting for a full buffer. The idle filler is OFF.'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: (int)(rf_freq)
    len_tag_key: packet_len
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '2048'
    comment: buffer 2048 = 2.05 ms carrier-sense latency. At the stock 32768 it would be 32.8 ms, longer than a whole frame, and CSMA would be useless.
    filter_source: '''Auto'''
    frequency: (int)(rf_freq)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: link_layer
  id: epy_block
  parameters:
    _source_code: |
      """GNU Radio shim for the SHARED-CHANNEL (CSMA/CA) BPSK chat node - r6b.

      Derived from bpsk_duplex_pluto_link_layer.py, which stays exactly as it is and
      still drives the FDD flowgraph. Two differences:

        * every outbound frame goes through bpsk_mac.MacState instead of straight to
          the modulator, so it has to win the channel first;
        * a second complex input carries the raw receive stream for carrier sense.

      Input ports
        0  recovered symbols from the Costas loop - EVM and SNR, measurement only
        1  the raw receive stream decimated by sps - carrier sense energy

      Both ports must be at the SAME sample rate: a sync block consumes equally from
      all of its inputs. Port 0 is one sample per symbol, so the raw stream is
      decimated by sps with a Keep 1 in N block before it reaches port 1. Energy
      detection is unaffected by that decimation.

      Three files must sit in the same directory as the flowgraph:

          bpsk_link.py    framing, addressing, stop-and-wait ARQ, file segmentation
          bpsk_app.py     chat model, delivery receipts, HTTP + SSE server
          chat_ui.html    the browser front end

      This block owns none of that logic. It converts PMT to bytes, drives the
      state machine, and measures the recovered constellation so the UI can show
      signal quality. The chat UI is served on 127.0.0.1:<http_port> and starts on
      the first tick rather than in __init__, because GRC instantiates this block
      every time it validates the flowgraph and must not be left holding a socket.

      `peers` is a comma-separated list of the addresses this node talks to,
      for example "2,3,4". Leave it empty for a two-node link and peer_addr is
      used instead. Unlisted nodes are discovered on first contact.

      Input port 0 takes the recovered symbol stream (the Costas loop output). It
      is used only for the EVM and level estimates in the status bar; the data path
      does not run through this block.
      """

      import os
      import sys
      import threading
      import time

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by absolute path, never by module name.

          GRC validates this block by running exec() on this source in an empty
          namespace, so there is no __file__ and the working directory is wherever
          GRC was started. Loading the file directly makes both irrelevant, and
          swallowing every failure keeps a missing module from painting the block
          red in the editor - __init__ reports it on the console instead.
          """
          import importlib.util

          if name in sys.modules:
              return sys.modules[name]

          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([entry for entry in sys.path if entry])

          for root in roots:
              path = os.path.join(root, name + '.py')
              if not os.path.isfile(path):
                  continue
              spec = importlib.util.spec_from_file_location(name, path)
              module = importlib.util.module_from_spec(spec)
              sys.modules[name] = module
              try:
                  spec.loader.exec_module(module)
              except Exception:
                  sys.modules.pop(name, None)
                  raise
              return module
          return None


      _load_error = ''
      try:
          bpsk_link = _load('bpsk_link')
          bpsk_app = _load('bpsk_app') if bpsk_link is not None else None
          bpsk_mac = _load('bpsk_mac') if bpsk_link is not None else None
          if bpsk_app is None or bpsk_mac is None:
              _load_error = ('bpsk_link.py / bpsk_app.py / bpsk_mac.py not found '
                             'next to the flowgraph')
      except Exception as _err:            # noqa: BLE001 - reported, never raised
          bpsk_link = bpsk_app = bpsk_mac = None
          _load_error = repr(_err)


      def _to_text(msg):
          """Accept whatever the QT edit box emits and return a str."""
          try:
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg)
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_u8vector(val):
                      return bytes(bytearray(pmt.u8vector_elements(val))).decode(
                          'utf-8', 'replace')
                  if pmt.is_symbol(val):
                      return pmt.symbol_to_string(val)
          except Exception:
              pass
          return None


      def _to_bytes(msg):
          """Extract the u8vector of a PDU as bytes."""
          try:
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_u8vector(val):
                      return bytes(bytearray(pmt.u8vector_elements(val)))
          except Exception:
              pass
          return None


      class blk(gr.sync_block):
          """BPSK chat node: ARQ link layer, application layer and browser UI."""

          def __init__(self, my_addr=1, peer_addr=2, ack_timeout=0.5, max_retries=5,
                       frag_size=256, queue_ahead=0.03, sym_rate=250000.0,
                       overhead=460, rx_dir='.', nickname='', http_port=8088,
                       open_ui=True, tx_freq=0.0, rx_freq=0.0, peers='',
                       mac_slot=0.003, cw_min=8, cw_max=128,
                       busy_threshold_db=-55.0, beacon_interval=2.0,
                       peer_timeout=8.0):
              gr.sync_block.__init__(self, name='BPSK CSMA Chat Node',
                                     in_sig=[np.complex64, np.complex64], out_sig=[])
              self.http_port = int(http_port)
              self.open_ui = bool(open_ui)
              self.app = None
              self.link = None
              self.mac = None
              if bpsk_app is None:
                  print('[chat] ERROR: could not load the protocol modules: %s'
                        % _load_error, flush=True)
              else:
                  # "2,3,4" from the flowgraph; empty falls back to the single
                  # peer_addr so a two-node setup needs no extra configuration.
                  roster = [int(tok) for tok in str(peers).replace(';', ',').split(',')
                            if tok.strip().isdigit()] or None
                  store = os.path.join(os.path.abspath(rx_dir or '.'), 'chat_files')
                  self.app = bpsk_app.ChatApp(
                      my_addr=my_addr, peer_addr=peer_addr,
                      nick=(nickname or ('Node %d' % my_addr)), store_dir=store,
                      ack_timeout=ack_timeout, max_retries=max_retries,
                      frag_size=frag_size, queue_ahead=queue_ahead,
                      sym_rate=sym_rate, overhead=overhead,
                      tx_freq=tx_freq, rx_freq=rx_freq, peers=roster,
                      beacon_interval=beacon_interval, peer_timeout=peer_timeout)
                  self.link = self.app.link
                  self.mac = bpsk_mac.MacState(
                      slot=mac_slot, cw_min=int(cw_min), cw_max=int(cw_max),
                      overhead=overhead, sym_rate=sym_rate,
                      busy_threshold_db=busy_threshold_db)

              for port in ('chat_in', 'rx_frame', 'tick'):
                  self.message_port_register_in(pmt.intern(port))
              for port in ('tx_frame', 'log'):
                  self.message_port_register_out(pmt.intern(port))
              self.set_msg_handler(pmt.intern('chat_in'), self._on_chat)
              self.set_msg_handler(pmt.intern('rx_frame'), self._on_rx)
              self.set_msg_handler(pmt.intern('tick'), self._on_tick)

              self._lock = threading.RLock()
              self._last_strobe = 0.0
              self._watchdog = None
              self._server = None
              self._meas_t = 0.0
              self._opened = False
              # Set by stop(). Everything that can touch a message port or acquire a
              # resource checks it first: after stop() the runtime is tearing the
              # block down, and publishing to a port from a Python thread at that
              # point is a call into freed C++.
              self._halt = threading.Event()
              # Interned once. _dispatch runs up to 100 times a second.
              self._port_log = pmt.intern('log')
              self._port_tx = pmt.intern('tx_frame')
              if self.link is not None:
                  self._say(self.link.banner())

          # ------------------------------------------------------------ plumbing
          def _say(self, text):
              for line in str(text).splitlines():
                  print('[link] %s' % line, flush=True)
              if self._halt.is_set():
                  return
              self.message_port_pub(self._port_log, pmt.string_to_symbol(str(text)))

          def _dispatch(self, actions, now=None):
              """Frames go to the MAC to contend for the channel, not to the radio."""
              if self._halt.is_set():
                  return
              now = time.time() if now is None else now
              for kind, value in actions:
                  if kind == 'tx':
                      self.mac.enqueue(value, now)
                  elif kind == 'log':
                      self._say(value)
              self._drain_mac(now)

          def _drain_mac(self, now):
              """Publish whatever the MAC has cleared for transmission."""
              if self._halt.is_set() or self.mac is None:
                  return
              for frame in self.mac.on_tick(now):
                  vec = pmt.init_u8vector(len(frame), list(bytearray(frame)))
                  self.message_port_pub(self._port_tx, pmt.cons(pmt.PMT_NIL, vec))

          # -------------------------------------------------------------- startup
          def _ensure_running(self):
              """Start the UI server and the fallback timer on first traffic.

              Deferred out of __init__ so that GRC, which instantiates this block
              every time it validates the flowgraph, never binds the port or spawns
              a thread.
              """
              if self.app is None or self._halt.is_set():
                  return
              if self._server is None:
                  try:
                      self._server, _ = bpsk_app.serve(self.app, self.http_port)
                      url = 'http://127.0.0.1:%d/' % self.http_port
                      self._say('chat UI ready at %s  (files in %s)'
                                % (url, self.app.store_dir))
                      if self.open_ui and not self._opened:
                          self._opened = True
                          threading.Thread(target=self._open_browser, args=(url,),
                                           daemon=True).start()
                  except OSError as exc:
                      self._server = False        # do not retry every 10 ms
                      self._say('could not start the chat UI on port %d: %s'
                                % (self.http_port, exc))
              if self._watchdog is None:
                  self._watchdog = threading.Thread(target=self._watchdog_loop,
                                                    daemon=True)
                  self._watchdog.start()

          @staticmethod
          def _open_browser(url):
              import webbrowser
              time.sleep(0.7)
              try:
                  webbrowser.open(url)
              except Exception:
                  pass

          def stop(self):
              """Stop the watchdog and release the port, in that order.

              Order matters. The watchdog drives on_tick and publishes the frames it
              produces; left running it keeps calling message_port_pub while the
              runtime destroys the block. Because stop() also freezes _last_strobe,
              the watchdog ENGAGES within 250 ms of teardown and then publishes at
              100 Hz, so this is the steady state during shutdown, not a rare race.
              """
              self._halt.set()
              watchdog, self._watchdog = self._watchdog, None
              if watchdog is not None and watchdog.is_alive():
                  watchdog.join(timeout=1.0)
              server, self._server = self._server, None
              if server:
                  bpsk_app.shutdown(server)
              if self.app is not None:
                  self.app.close()
              return True

          # -------------------------------------------------------- message ports
          def _watchdog_loop(self):
              """Drive on_tick if the Message Strobe stops delivering.

              Every ARQ timer and the transmit filler hang off the tick port. If that
              port goes quiet the link silently wedges: nothing retransmits, the
              queue never drains, and the Pluto TX buffer starves. This takes over
              after 250 ms of silence and stands down if the strobe returns.
              """
              engaged = False
              while not self._halt.is_set():
                  if self._halt.wait(0.01):
                      return                      # stop() asked us to leave
                  try:
                      with self._lock:
                          if self.app is None or self._halt.is_set():
                              continue
                          if (time.time() - self._last_strobe) < 0.25:
                              if engaged:
                                  engaged = False
                                  self._say('message strobe recovered, watchdog '
                                            'standing down')
                              continue
                          if not engaged:
                              engaged = True
                              self._say('WARNING: no tick from the Message Strobe '
                                        'block - driving ARQ timers and TX filler '
                                        'from the fallback thread instead')
                          now = time.time()
                          self._dispatch(self.app.on_tick(now), now)
                  except Exception as exc:
                      print('[chat] watchdog error: %r' % (exc,), flush=True)

          def _on_chat(self, msg):
              if self.app is None or self._halt.is_set():
                  return
              text = _to_text(msg)
              if text is None:
                  return
              with self._lock:
                  self._ensure_running()
                  self._dispatch(self.app.on_console(text, time.time()))

          def _on_rx(self, msg):
              if self.app is None or self._halt.is_set():
                  return
              raw = _to_bytes(msg)
              if raw is None:
                  return
              with self._lock:
                  self._ensure_running()
                  now = time.time()
                  self.mac.note_rx(raw, now)      # hold off for the ACK it will draw
                  self._dispatch(self.app.on_rx(raw, now), now)

          def _on_tick(self, msg):
              if self.app is None or self._halt.is_set():
                  return
              with self._lock:
                  now = time.time()
                  self._last_strobe = now
                  self._ensure_running()
                  self._dispatch(self.app.on_tick(now), now)

          # ------------------------------------------------ constellation quality
          def work(self, input_items, output_items):
              """Estimate EVM and level from the recovered symbols.

              The samples are not part of the data path - they are only measured.
              Decisions are taken on the real axis, which is what a locked
              differential BPSK receiver produces after the Costas loop, so the
              residual is everything the modem failed to clean up: noise, timing
              jitter, and any phase the loop has not tracked out.
              """
              sym = input_items[0]
              raw = input_items[1]
              now = time.time()
              if self._halt.is_set():
                  return len(sym)

              # Carrier sense first: it must be prompt, so it is measured on every
              # call rather than on the 200 ms EVM cadence. The block itself is
              # short because the Pluto source buffer is 2048 samples - that is what
              # keeps sensing latency near 2 ms instead of the 33 ms the stock
              # 32768-sample buffer would impose, which is longer than a whole frame.
              if self.mac is not None and len(raw):
                  power = float(np.mean(np.abs(raw) ** 2)) + 1e-15
                  self.mac.set_level(10.0 * np.log10(power), now)
              if self.app is not None and (now - self._meas_t) >= 0.2 and len(sym):
                  self._meas_t = now
                  block = np.asarray(sym[:4096], dtype=np.complex64)
                  power = float(np.mean(np.abs(block) ** 2))
                  amp = float(np.mean(np.abs(block.real)))
                  if amp > 1e-4:
                      err = block - np.sign(block.real) * amp
                      evm = float(np.sqrt(np.mean(np.abs(err) ** 2)) / amp)
                      evm = min(max(evm, 1e-3), 10.0)
                      snr = -20.0 * np.log10(evm)
                      self.app.set_radio_metrics(
                          snr_db=round(snr, 2),
                          level_db=round(10.0 * np.log10(power + 1e-12), 1),
                          evm=round(100.0 * evm, 2),
                          locked=bool(snr > 5.0))
                      if self.mac is not None:
                          self.app.set_mac_state(self.mac.snapshot(now))
                  else:
                      self.app.set_radio_metrics(snr_db=None, level_db=None,
                                                 evm=None, locked=False)
              return len(sym)
    ack_timeout: ack_timeout
    comment: CSMA/CA medium access - see bpsk_mac.py
    frag_size: frag_size
    max_retries: max_retries
    my_addr: my_addr
    overhead: preamble_size+postamble_size+12
    peer_addr: peer_addr
    queue_ahead: queue_ahead
    rx_dir: '"."'
    sym_rate: samp_rate/sps
    nickname: nickname
    http_port: http_port
    open_ui: 'True'
    tx_freq: tx_freq
    rx_freq: rx_freq
    peers: peers
    mac_slot: mac_slot
    cw_min: cw_min
    cw_max: cw_max
    busy_threshold_db: busy_threshold_db
    beacon_interval: beacon_interval
    peer_timeout: peer_timeout
  states: {}
- name: my_addr
  id: parameter
  parameters:
    comment: 'node A: 1   node B: 2'
    label: My address
    type: intx
    value: '1'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: CRC is checked in bpsk_link.parse()
    tag: packet_len
    type: byte
  states: {}
- name: peer_addr
  id: parameter
  parameters:
    label: Peer address
    type: intx
    value: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: two tight blobs = locked
    grid: 'True'
    gui_hint: '[1, 1, 2, 1]'
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: fallback console - the chat UI is served on http_port
    gui_hint: '[0, 0, 1, 2]'
    is_pair: 'False'
    key: '""'
    label: '"Console  (the chat lives in the browser; /stats, /help here)"'
    type: string
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: peer signal should sit at centre
    fc: rx_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[1, 0, 2, 1]'
    name: '"RX Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[3, 0, 2, 2]'
    label1: Real
    label2: Imag
    name: '"Recovered Symbols"'
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_tx
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 2, 1]'
    label1: Real
    label2: Imag
    name: '"Transmit waveform"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 'node A: 910.2M   node B: 905.2M'
    label: RX carrier (Hz)
    type: eng_float
    value: 910.2e6
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    comment: 'node A: 905.2M   node B: 910.2M'
    label: TX carrier (Hz)
    type: eng_float
    value: 905.2e6
  states: {}
- name: uri
  id: parameter
  parameters:
    comment: this node's own Pluto
    label: Pluto URI
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_header
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_payload
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_recovery
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_header
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_payload
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_recovery
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}
- name: nickname
  id: parameter
  parameters:
    comment: shown on the peer's chat bubbles
    label: Chat nickname
    type: str
    value: Node A
  states: {}
- name: http_port
  id: parameter
  parameters:
    comment: open http://127.0.0.1:<port>/ in a browser
    label: Chat UI port
    type: intx
    value: '8088'
  states: {}
- name: peers
  id: parameter
  parameters:
    comment: comma separated, e.g. 2,3,4 - empty uses peer_addr
    label: Peer addresses
    type: str
    value: '2'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: 'match port 0 rate: a sync block consumes equally from all inputs'
    n: sps
    type: complex
  states: {}
- name: rf_freq
  id: parameter
  parameters:
    comment: ONE channel for every node - TDD, not FDD
    label: Shared carrier (Hz)
    type: eng_float
    value: 915.0e6
  states: {}
- name: mac_slot
  id: parameter
  parameters:
    comment: must be >= carrier-sense latency (2.05 ms at buffer 2048)
    label: MAC slot (s)
    type: eng_float
    value: '0.003'
  states: {}
- name: cw_min
  id: parameter
  parameters:
    label: CW min (slots)
    type: intx
    value: '8'
  states: {}
- name: cw_max
  id: parameter
  parameters:
    label: CW max (slots)
    type: intx
    value: '128'
  states: {}
- name: busy_threshold_db
  id: parameter
  parameters:
    comment: tune against your measured noise floor
    label: Busy threshold (dB)
    type: eng_float
    value: '-55.0'
  states: {}
- name: beacon_interval
  id: parameter
  parameters:
    comment: liveness with no idle filler
    label: Beacon (s)
    type: eng_float
    value: '2.0'
  states: {}
- name: peer_timeout
  id: parameter
  parameters:
    label: Peer timeout (s)
    type: eng_float
    value: '8.0'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, link_layer, tick]
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_tx, '0']
- [blocks_repack_bits_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_post, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_stream_to_tagged_stream_pre, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_pre, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_post, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', link_layer, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_rx, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_recovery, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_fll_band_edge_cc_0, '0', filter_fft_rrc_filter_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_header, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [link_layer, tx_frame, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_payload, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, link_layer, rx_frame]
- [qtgui_edit_box_msg_0, msg, link_layer, chat_in]
- [virtual_source_header, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_payload, '0', blocks_tagged_stream_mux_0, '2']
- [virtual_source_recovery, '0', digital_constellation_decoder_cb_0, '0']
- [iio_pluto_source_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', link_layer, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
