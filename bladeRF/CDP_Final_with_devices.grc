options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: CDP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 443e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: '"frame_sync"'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101100011000100000110111001101'
    tagname: '"frame_sync"'
    threshold: '4'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2, 3]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_0
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '4'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class header_frame_trim(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="Header Frame Trim", in_sig=None, out_sig=None)
              self.buffer = []
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              new_bytes = list(pmt.u8vector_elements(pmt.cdr(msg)))
              self.buffer.extend(new_bytes)

              # Valid node addresses in our network
              VALID_DESTS = [1, 2, 255]
              VALID_SRCS = [1, 2]

              while len(self.buffer) >= 3:
                  dest_id = self.buffer[0]
                  src_id = self.buffer[1]
                  payload_len = self.buffer[2]

                  # Aggressively drop inter-packet noise / preamble bytes
                  if dest_id not in VALID_DESTS or src_id not in VALID_SRCS or payload_len < 1 or payload_len > 128:
                      self.buffer.pop(0)
                      continue

                  # Total frame length = Header(3) + Payload + CRC(4)
                  exact_frame_len = 3 + payload_len + 4

                  # Wait until the full packet arrives
                  if len(self.buffer) < exact_frame_len:
                      break

                  # Extract clean packet and publish
                  clean_packet = self.buffer[:exact_frame_len]
                  pdu_out = pmt.init_u8vector(len(clean_packet), clean_packet)
                  self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))

                  # Advance buffer past the processed packet
                  self.buffer = self.buffer[exact_frame_len:]
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class add_header(gr.basic_block):
          def __init__(self, dest_id=2, src_id=1):
              gr.basic_block.__init__(self, name="Add Header", in_sig=None, out_sig=None)
              self.dest_id = dest_id
              self.src_id = src_id
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              payload = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # 3-Byte Header: [DEST_ID, SRC_ID, PAYLOAD_LEN]
              header = [self.dest_id, self.src_id, len(payload)]
              packet = header + payload
              
              pdu_out = pmt.init_u8vector(len(packet), packet)
              self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))
    dest_id: '2'
    src_id: '1'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import sys

      class address_ack(gr.basic_block):
          def __init__(self, my_id=2):
              gr.basic_block.__init__(self, name="Address Filter & ACK", in_sig=None, out_sig=None)
              self.my_id = my_id
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("payload_out"))
              self.message_port_register_out(pmt.mp("ack_out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              if len(vec) < 3:
                  return
              
              dest_id = vec[0]
              src_id = vec[1]
              payload_len = vec[2]
              
              if len(vec) < 3 + payload_len:
                  return

              payload = vec[3 : 3 + payload_len]

              # Accept frames for My ID (2), Broadcast (255), or Sender ID (1)
              if dest_id == self.my_id or dest_id == 255 or dest_id == 1:
                  is_ack = (payload == [0x41, 0x43, 0x4B]) # "ACK"
                  
                  if not is_ack:
                      msg_text = bytes(payload).decode('utf-8', errors='ignore').strip()
                      
                      # Use sys.__stdout__ to bypass GNU Radio's GUI logging capture
                      sys.__stdout__.write("\n=================================\n")
                      sys.__stdout__.write(f"[DECODED PAYLOAD]: {msg_text}\n")
                      sys.__stdout__.write("=================================\n\n")
                      sys.__stdout__.flush()

                      # Send ACK frame back to transmitter
                      ack_data = [src_id, self.my_id, 3, 0x41, 0x43, 0x4B] 
                      ack_pdu = pmt.init_u8vector(len(ack_data), ack_data)
                      self.message_port_pub(pmt.mp("ack_out"), pmt.cons(meta, ack_pdu))
                  else:
                      sys.__stdout__.write("\n=================================\n")
                      sys.__stdout__.write(f"[ACK RECEIVED] From Node {src_id}\n")
                      sys.__stdout__.write("=================================\n\n")
                      sys.__stdout__.flush()
                  
                  pdu_out = pmt.init_u8vector(len(payload), payload)
                  self.message_port_pub(pmt.mp("payload_out"), pmt.cons(meta, pdu_out))
    my_id: '2'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class add_preamble_pad(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="Add Preamble & Pad", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # Pad short messages to at least 16 bytes
              min_bytes = 16
              if len(vec) < min_bytes:
                  vec += [0x00] * (min_bytes - len(vec))
                  
              # FIX: Increased dummy preamble from 48 to 128 bytes for cold-start AGC lock
              dummy = [0x55] * 128
              preamble = [0xAC, 0x62, 0x0D, 0xCD]
              
              full_packet = dummy + preamble + vec
              pdu_out = pmt.init_u8vector(len(full_packet), full_packet)
              self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"packet_len"'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    ant0: TX1
    center_freq0: freq
    dev: driver=bladerf,tx_gain=15
    devname: custom
    manual_gain0: 'False'
    overall_gain0: '42'
    pga_gain0: '0'
    samp_rate: samp_rate
    txvga1_gain: '0'
    type: fc32
    vga_gain0: '0'
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'False'
    devname: rtlsdr
    overall_gain0: '38'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', soapy_sink_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_crc32_async_bb_0, out, epy_block_3, in]
- [digital_crc32_async_bb_1, out, epy_block_2, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0, out, digital_crc32_async_bb_1, in]
- [epy_block_1, out, digital_crc32_async_bb_0, in]
- [epy_block_2, payload_out, blocks_message_debug_0, print]
- [epy_block_3, out, pdu_pdu_to_tagged_stream_0, pdus]
- [network_socket_pdu_0, pdus, epy_block_1, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_0, in]
- [soapy_source_0, '0', dc_blocker_xx_0, '0']
- [soapy_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
