options:
  parameters:
    author: rootr
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: msg_BPSK_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk_const
  id: variable_constellation
  parameters:
    const_points: '[-1.0-0.0j, 1.0+0.0j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1]'
    type: calcdist
  states: {}
- name: freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: rx_rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1.0, samp_rate, sym_rate, 0.35, 11*sps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: samp_rate / sps
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: '''naive tests'''
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk_const
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '0010110111010100'
    tagname: '"sync"'
    threshold: '2'
    type: float
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.0628'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rx_rrc_taps
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"BPSK Demodulation"'
    size: '1024'
    type: complex
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    dev_args: driver=bladerf
    devname: bladerf
    overall_gain0: '40'
    samp_rate: samp_rate
    type: sc8
  states: {}

connections:
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', digital_symbol_sync_xx_0, '0']
- [soapy_source_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
