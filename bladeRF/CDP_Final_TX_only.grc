options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: CDP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 443e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '4'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class add_header(gr.basic_block):
          def __init__(self, dest_id=2, src_id=1):
              gr.basic_block.__init__(self, name="Add Header", in_sig=None, out_sig=None)
              self.dest_id = dest_id
              self.src_id = src_id
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              payload = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # 3-Byte Header: [DEST_ID, SRC_ID, PAYLOAD_LEN]
              header = [self.dest_id, self.src_id, len(payload)]
              packet = header + payload
              
              pdu_out = pmt.init_u8vector(len(packet), packet)
              self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))
    dest_id: '2'
    src_id: '1'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class add_preamble_pad(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="Add Preamble & Pad", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = list(pmt.u8vector_elements(pmt.cdr(msg)))
              
              # Pad short messages to at least 16 bytes
              min_bytes = 16
              if len(vec) < min_bytes:
                  vec += [0x00] * (min_bytes - len(vec))
                  
              # FIX: Increased dummy preamble from 48 to 128 bytes for cold-start AGC lock
              dummy = [0x55] * 128
              preamble = [0xAC, 0x62, 0x0D, 0xCD]
              
              full_packet = dummy + preamble + vec
              pdu_out = pmt.init_u8vector(len(full_packet), full_packet)
              self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '2000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.1.10
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    type: UDP_SERVER
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_time_sink_x_0, '0']
- [digital_crc32_async_bb_0, out, epy_block_3, in]
- [epy_block_1, out, digital_crc32_async_bb_0, in]
- [epy_block_3, out, pdu_pdu_to_tagged_stream_0, pdus]
- [network_socket_pdu_0, pdus, epy_block_1, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
