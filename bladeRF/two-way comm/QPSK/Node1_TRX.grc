options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: Node1_TRX
    output_language: python
    title: Node1_TRX - EN2130 SDR TRX
  states: {}

blocks:
- name: app_rx_port
  id: variable
  parameters:
    value: '52002'
  states: {}
- name: app_tx_port
  id: variable
  parameters:
    value: '52001'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: my_id
  id: variable
  parameters:
    value: '1'
  states: {}
- name: peer_id
  id: variable
  parameters:
    value: '2'
  states: {}
- name: pluto_uri
  id: variable
  parameters:
    value: '''ip:192.168.1.10'''
  states: {}
- name: rx_freq
  id: variable
  parameters:
    value: 438.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 433.0e6
  states: {}
- name: variable_constellation_0
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: packet_len
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: frame_sync
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_0
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_0
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101100011000100000110111001101'
    tagname: frame_sync
    threshold: '4'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
    comment: shared by app-data path AND the ACK echo path (fan-in)
  states: {}
- name: digital_crc32_async_bb_2
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
    comment: 'check=True: drops any frame that fails CRC (error-detection requirement)'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 2, 3]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: variable_constellation_0
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: epy_block_addr_filter_ack
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt
      import sys

      HDR_LEN = 7
      TYPE_ACK = 3
      BROADCAST = 255


      class addr_filter_ack(gr.basic_block):
          """Runs on CRC-verified frames only (digital_crc32_async_bb in check
          mode already dropped anything corrupted upstream of this block).
          Enforces unique addressing, forwards accepted frames to the app, and
          auto-generates + transmits an ACK for anything that isn't itself an
          ACK."""

          def __init__(self, my_id=1):
              gr.basic_block.__init__(self, name="Address Filter + Auto-ACK", in_sig=None, out_sig=None)
              self.my_id = my_id
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("payload_out"))
              self.message_port_register_out(pmt.mp("ack_out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              frame = list(pmt.u8vector_elements(pmt.cdr(msg)))

              if len(frame) < HDR_LEN:
                  return

              dest_id, src_id, msg_id, frag_idx, frag_tot, msg_type, length = frame[:HDR_LEN]

              if dest_id != self.my_id and dest_id != BROADCAST:
                  return  # not addressed to us -- unique-addressing requirement

              # Hand the whole validated frame (header+payload) up to the app.
              # Covers both data fragments and ACK frames; the app tells them
              # apart by the `type` byte in the header.
              pdu_out = pmt.init_u8vector(len(frame), frame)
              self.message_port_pub(pmt.mp("payload_out"), pmt.cons(meta, pdu_out))

              sys.__stdout__.write(
                  f"[RX] type={msg_type} src={src_id} msg_id={msg_id} "
                  f"frag={frag_idx}/{frag_tot} len={length}\n"
              )
              sys.__stdout__.flush()

              if msg_type != TYPE_ACK:
                  ack = [src_id, self.my_id, msg_id, frag_idx, 1, TYPE_ACK, 0]
                  ack_pdu = pmt.init_u8vector(len(ack), ack)
                  self.message_port_pub(pmt.mp("ack_out"), pmt.cons(meta, ack_pdu))
    my_id: my_id
  states: {}
- name: epy_block_frame_trim
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      HDR_LEN = 7
      MAX_FRAG_PAYLOAD = 180  # must match link_layer.py's MAX_FRAG_PAYLOAD


      class frame_trim(gr.basic_block):
          """Slices the continuous demodulated byte stream (arriving as PDUs from
          pdu_tagged_stream_to_pdu, one access-code-synced burst at a time) into
          exact-length frames using the 7-byte header's `len` field. Bogus header
          bytes (from noise that happened to correlate against the access code)
          are resynced past one byte at a time rather than stalling the buffer."""

          def __init__(self):
              gr.basic_block.__init__(self, name="Frame Trim", in_sig=None, out_sig=None)
              self.buffer = []
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              self.buffer.extend(list(pmt.u8vector_elements(pmt.cdr(msg))))

              while len(self.buffer) >= HDR_LEN:
                  msg_type = self.buffer[5]
                  payload_len = self.buffer[6]

                  # Sanity-check the header before committing to a frame length;
                  # if it looks bogus, drop one byte and keep scanning.
                  if msg_type > 3 or payload_len > MAX_FRAG_PAYLOAD:
                      self.buffer.pop(0)
                      continue

                  exact_len = HDR_LEN + payload_len + 4  # +4 for CRC32 trailer

                  if len(self.buffer) < exact_len:
                      break  # wait for more bytes

                  frame = self.buffer[:exact_len]
                  pdu_out = pmt.init_u8vector(len(frame), frame)
                  self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))
                  self.buffer = self.buffer[exact_len:]
  states: {}
- name: epy_block_preamble_pad
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt


      class add_preamble_pad(gr.basic_block):
          """Unchanged from the earlier working prototype: pads short frames to
          16 bytes minimum, then prepends a 128-byte 0x55 dummy preamble (for
          AGC/loop settling on a bursty link) and the 4-byte access code."""

          def __init__(self):
              gr.basic_block.__init__(self, name="Add Preamble & Pad", in_sig=None, out_sig=None)
              self.message_port_register_in(pmt.mp("in"))
              self.message_port_register_out(pmt.mp("out"))
              self.set_msg_handler(pmt.mp("in"), self.handle_msg)

          def handle_msg(self, msg):
              meta = pmt.car(msg)
              vec = list(pmt.u8vector_elements(pmt.cdr(msg)))

              min_bytes = 16
              if len(vec) < min_bytes:
                  vec += [0x00] * (min_bytes - len(vec))

              dummy = [0x55] * 128
              preamble = [0xAC, 0x62, 0x0D, 0xCD]

              full_packet = dummy + preamble + vec
              pdu_out = pmt.init_u8vector(len(full_packet), full_packet)
              self.message_port_pub(pmt.mp("out"), pmt.cons(meta, pdu_out))
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(tx_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: '32768'
    comment: VERIFY gain_mode/manual_gain fields after opening -- see checklist
    filter_source: '''Auto'''
    frequency: int(rx_freq)
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: pluto_uri
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: 'app -> GRC: fully-formed 7B-header frames to transmit'
    host: 127.0.0.1
    mtu: '10000'
    port: app_tx_port
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: 'GRC -> app: validated data frames AND ACK frames'
    host: 127.0.0.1
    mtu: '10000'
    port: app_rx_port
    type: UDP_CLIENT
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_rx
  id: qtgui_const_sink_x
  parameters:
    name: ''
    size: '1024'
    tr_tag: ''
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_tx
  id: qtgui_const_sink_x
  parameters:
    name: ''
    size: '1024'
    tr_tag: ''
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    name: ''
    tr_tag: ''
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: rx_freq
    fftsize: '1024'
    name: ''
    type: complex
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_align_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [dc_blocker_xx_0, '0', analog_agc_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_tx, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_rx, '0']
- [digital_crc32_async_bb_0, out, epy_block_preamble_pad, in]
- [digital_crc32_async_bb_2, out, epy_block_addr_filter_ack, in]
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_addr_filter_ack, ack_out, digital_crc32_async_bb_0, in]
- [epy_block_addr_filter_ack, payload_out, network_socket_pdu_1, pdus]
- [epy_block_frame_trim, out, digital_crc32_async_bb_2, in]
- [epy_block_preamble_pad, out, pdu_pdu_to_tagged_stream_0, pdus]
- [iio_pluto_source_0, '0', dc_blocker_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [network_socket_pdu_0, pdus, digital_crc32_async_bb_0, in]
- [pdu_pdu_to_tagged_stream_0, '0', digital_constellation_modulator_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, epy_block_frame_trim, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
