options:
  parameters:
    author: Rivija Pesara (framing from Barry Duggan BPSK example)
    description: Full-duplex FDD BPSK link with addressing and stop-and-wait ARQ
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: bpsk_duplex_pluto
    output_language: python
    title: BPSK Duplex Link (Pluto, FDD)
  states: {}

blocks:
- name: ack_timeout
  id: variable
  parameters:
    comment: seconds before retransmit
    value: '0.5'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: frag_size
  id: variable
  parameters:
    comment: payload bytes per frame
    value: '256'
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: max_retries
  id: variable
  parameters:
    value: '5'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    comment: symbols of unmodulated run-in
    value: '384'
  states: {}
- name: queue_ahead
  id: variable
  parameters:
    comment: seconds of TX buffer kept full; 0 disables idle filler
    value: '0.03'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    comment: 'manual, not AGC: AGC would ride our own TX leakage'
    label: Rx Gain (dB)
    start: '0'
    step: '1'
    stop: '73'
    value: '45'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    comment: 'NOTE: attenuation, lower = more power'
    label: Tx Attenuation (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '20'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: drives ARQ timers and the TX filler
    msg: pmt.intern("tick")
    period: '10'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    align_output: 'True'
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: packet_len
  states: {}
- name: blocks_stream_to_tagged_stream_post
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_pre
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: preamble | PHY header | frame | postamble
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: threshold = bit errors tolerated in the 64-bit access code
    tagname: packet_len
    threshold: '2'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: len(constel.points())
    w: 3.14/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: len(constel.points())
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    comment: tracks XO offset between the two Plutos
    filter_size: '44'
    improved_loop_filter: 'False'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: '0.03'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '1000000'
    buffer_size: '8192'
    comment: 'FDD: transmits on tx_freq while the source receives on rx_freq'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: (int)(tx_freq)
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '1000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: narrow BW rejects our own TX leakage 5 MHz away
    filter_source: '''Auto'''
    frequency: (int)(rx_freq)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: link_layer
  id: epy_block
  parameters:
    _source_code: |
      """GNU Radio shim for the BPSK duplex link layer.

      The protocol lives in bpsk_link.py, which must sit in the same directory as
      this flowgraph.
      """

      import os
      import sys
      import threading
      import time

      import pmt
      from gnuradio import gr


      def _load_protocol():
          """Load bpsk_link.py by absolute path, never by module name.

          GRC validates this block by running exec() on this source in an empty
          namespace, so there is no __file__ and the working directory is wherever
          GRC was started. Loading the file directly makes both irrelevant, and
          swallowing every failure keeps a missing module from painting the block
          red in the editor - __init__ reports it on the console instead.
          """
          import importlib.util

          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([entry for entry in sys.path if entry])

          for root in roots:
              path = os.path.join(root, 'bpsk_link.py')
              if not os.path.isfile(path):
                  continue
              spec = importlib.util.spec_from_file_location('bpsk_link', path)
              module = importlib.util.module_from_spec(spec)
              spec.loader.exec_module(module)
              sys.modules['bpsk_link'] = module
              return module
          return None


      try:
          bpsk_link = _load_protocol()
      except Exception as _err:
          bpsk_link = None
          _load_error = repr(_err)
      else:
          _load_error = 'bpsk_link.py not found next to the flowgraph'


      def _to_text(msg):
          """Accept whatever the QT edit box emits and return a str."""
          try:
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg)
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_u8vector(val):
                      return bytes(bytearray(pmt.u8vector_elements(val))).decode(
                          'utf-8', 'replace')
                  if pmt.is_symbol(val):
                      return pmt.symbol_to_string(val)
          except Exception:
              pass
          return None


      def _to_bytes(msg):
          """Extract the u8vector of a PDU as bytes."""
          try:
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_u8vector(val):
                      return bytes(bytearray(pmt.u8vector_elements(val)))
          except Exception:
              pass
          return None


      class blk(gr.sync_block):
          """Addressed stop-and-wait ARQ link layer for the BPSK duplex radio."""

          def __init__(self, my_addr=1, peer_addr=2, ack_timeout=0.5, max_retries=5,
                       frag_size=256, queue_ahead=0.03, sym_rate=250000.0,
                       overhead=460, rx_dir='.'):
              gr.sync_block.__init__(self, name='BPSK Link Layer',
                                     in_sig=[], out_sig=[])
              if bpsk_link is None:
                  self.link = None
                  print('[link] ERROR: could not load bpsk_link.py: %s'
                        % _load_error, flush=True)
              else:
                  self.link = bpsk_link.LinkState(
                      my_addr, peer_addr, ack_timeout, max_retries, frag_size,
                      queue_ahead, sym_rate, overhead, rx_dir)
              for port in ('chat_in', 'rx_frame', 'tick'):
                  self.message_port_register_in(pmt.intern(port))
              for port in ('tx_frame', 'log'):
                  self.message_port_register_out(pmt.intern(port))
              self.set_msg_handler(pmt.intern('chat_in'), self._on_chat)
              self.set_msg_handler(pmt.intern('rx_frame'), self._on_rx)
              self.set_msg_handler(pmt.intern('tick'), self._on_tick)
              self._lock = threading.RLock()
              self._last_strobe = 0.0
              self._watchdog = None
              if self.link is not None:
                  self._say(self.link.banner())

          def _say(self, text):
              for line in str(text).splitlines():
                  print('[link] %s' % line, flush=True)
              self.message_port_pub(pmt.intern('log'),
                                    pmt.string_to_symbol(str(text)))

          def _dispatch(self, actions):
              for kind, value in actions:
                  if kind == 'tx':
                      vec = pmt.init_u8vector(len(value), list(bytearray(value)))
                      self.message_port_pub(pmt.intern('tx_frame'),
                                            pmt.cons(pmt.PMT_NIL, vec))
                  else:
                      self._say(value)

          def _ensure_watchdog(self):
              """Start the fallback timer thread on first traffic.

              Started lazily rather than in __init__ so that GRC, which instantiates
              this block every time it validates the flowgraph, never spawns one.
              """
              if self._watchdog is None and self.link is not None:
                  self._watchdog = threading.Thread(target=self._watchdog_loop,
                                                    daemon=True)
                  self._watchdog.start()

          def _watchdog_loop(self):
              """Drive on_tick if the Message Strobe stops delivering.

              Every ARQ timer and the transmit filler hang off the tick port. If that
              port goes quiet the link silently wedges: nothing retransmits, the
              queue never drains, and the Pluto TX buffer starves. This takes over
              after 250 ms of silence and stands down if the strobe returns.
              """
              engaged = False
              while True:
                  time.sleep(0.01)
                  try:
                      with self._lock:
                          if self.link is None:
                              continue
                          if (time.time() - self._last_strobe) < 0.25:
                              if engaged:
                                  engaged = False
                                  self._say('message strobe recovered, watchdog '
                                            'standing down')
                              continue
                          if not engaged:
                              engaged = True
                              self._say('WARNING: no tick from the Message Strobe '
                                        'block - driving ARQ timers and TX filler '
                                        'from the fallback thread instead')
                          self._dispatch(self.link.on_tick(time.time()))
                  except Exception as exc:
                      print('[link] watchdog error: %r' % (exc,), flush=True)

          def _on_chat(self, msg):
              if self.link is None:
                  return
              text = _to_text(msg)
              if text is None:
                  return
              with self._lock:
                  self._ensure_watchdog()
                  self._dispatch(self.link.on_user(text, time.time()))

          def _on_rx(self, msg):
              if self.link is None:
                  return
              raw = _to_bytes(msg)
              if raw is None:
                  return
              with self._lock:
                  self._ensure_watchdog()
                  self._dispatch(self.link.on_rx(raw, time.time()))

          def _on_tick(self, msg):
              if self.link is None:
                  return
              with self._lock:
                  self._last_strobe = time.time()
                  self._ensure_watchdog()
                  self._dispatch(self.link.on_tick(time.time()))

          def work(self, input_items, output_items):
              return 0
    ack_timeout: ack_timeout
    comment: framing, addressing, ARQ - see bpsk_link.py
    frag_size: frag_size
    max_retries: max_retries
    my_addr: my_addr
    overhead: preamble_size+postamble_size+12
    peer_addr: peer_addr
    queue_ahead: queue_ahead
    rx_dir: '"."'
    sym_rate: samp_rate/sps
  states: {}
- name: my_addr
  id: parameter
  parameters:
    comment: 'node A: 1   node B: 2'
    label: My address
    type: intx
    value: '2'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    comment: CRC is checked in bpsk_link.parse()
    tag: packet_len
    type: byte
  states: {}
- name: peer_addr
  id: parameter
  parameters:
    label: Peer address
    type: intx
    value: '1'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: two tight blobs = locked
    grid: 'True'
    gui_hint: '[1, 1, 2, 1]'
    name: '"Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: type a line and press Enter
    gui_hint: '[0, 0, 1, 2]'
    is_pair: 'False'
    key: '""'
    label: '"Send  (text, or /sendfile <path>, /stats, /help)"'
    type: string
    value: '""'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: peer signal should sit at centre
    fc: rx_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[1, 0, 2, 1]'
    name: '"RX Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_rx
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[3, 0, 2, 2]'
    label1: Real
    label2: Imag
    name: '"Recovered Symbols"'
    size: '256'
    srate: samp_rate/sps
    style2: '3'
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    update_time: '0.1'
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_tx
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[5, 0, 2, 1]'
    label1: Real
    label2: Imag
    name: '"Transmit waveform"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rx_freq
  id: parameter
  parameters:
    comment: 'node A: 910.2M   node B: 905.2M'
    label: RX carrier (Hz)
    type: eng_float
    value: 905.2e6
  states: {}
- name: tx_freq
  id: parameter
  parameters:
    comment: 'node A: 905.2M   node B: 910.2M'
    label: TX carrier (Hz)
    type: eng_float
    value: 910.2e6
  states: {}
- name: uri
  id: parameter
  parameters:
    comment: this node's own Pluto
    label: Pluto URI
    type: str
    value: ip:192.168.1.10
  states: {}
- name: virtual_sink_header
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_payload
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_sink_recovery
  id: virtual_sink
  parameters:
    stream_id: recovery
  states: {}
- name: virtual_source_header
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_payload
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_recovery
  id: virtual_source
  parameters:
    stream_id: recovery
  states: {}

connections:
- [blocks_message_strobe_0, strobe, link_layer, tick]
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_tx, '0']
- [blocks_repack_bits_bb_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_post, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_stream_to_tagged_stream_pre, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_pre, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_post, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_rx, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_recovery, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_fll_band_edge_cc_0, '0', filter_fft_rrc_filter_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_header, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_rrc_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [iio_pluto_source_0, '0', digital_fll_band_edge_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [link_layer, tx_frame, pdu_pdu_to_tagged_stream_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', virtual_sink_payload, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, link_layer, rx_frame]
- [qtgui_edit_box_msg_0, msg, link_layer, chat_in]
- [virtual_source_header, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_payload, '0', blocks_tagged_stream_mux_0, '2']
- [virtual_source_recovery, '0', digital_constellation_decoder_cb_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
