options:
  parameters:
    author: Rivija Pesara (framing from Barry Duggan BPSK example)
    catch_exceptions: 'False'
    description: 'BPSK network node: 4-channel FDMA mesh (6 MS/s, one-sided plan), self-assigned channels and addresses, closed-loop gain staging, Selective Repeat ARQ per peer, end-to-end encryption per pair, browser chat (r6.1-mesh)'
    generate_options: qt_gui
    id: bpsk_duplex_pluto
    output_language: python
    title: BPSK Mesh Node (Pluto, 4-channel FDMA, r6.1)
  states: {}

blocks:
- name: ack_timeout
  id: variable
  parameters:
    comment: seconds before retransmit
    value: '0.5'
  states: {}
- name: ch_rate
  id: variable
  parameters:
    comment: each channel after its channel filter
    value: sps*sym_rate
  states: {}
- name: ch_taps
  id: variable
  parameters:
    comment: 'pass +-175 kHz flat, stop from 425 kHz (65 dB): adjacent channels and the own transmitter on its channel'
    value: firdes.low_pass_2(1.0, radio_rate, 0.5*ch_spacing, 0.4167*ch_spacing, 65)
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: decim
  id: variable
  parameters:
    comment: channel filter decimation
    value: tx_interp//sps
  states: {}
- name: frag_size
  id: variable
  parameters:
    comment: bytes of file data per frame
    value: '256'
  states: {}
- name: max_retries
  id: variable
  parameters:
    value: '5'
  states: {}
- name: queue_ahead
  id: variable
  parameters:
    comment: seconds of airtime queued ahead of the radio
    value: '0.03'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: matched filter
    value: firdes.root_raised_cosine(1.0, ch_rate, sym_rate, 0.35, 11*sps)
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol in each receive chain
    value: '4'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    comment: 'symbols per second on every channel: 250k at 6 MS/s'
    value: radio_rate/tx_interp
  states: {}
- name: tx_interp
  id: variable
  parameters:
    comment: radio samples per symbol (6 MS/s / 250 ksym/s)
    value: '24'
  states: {}
- name: tx_scale
  id: variable
  parameters:
    comment: 'digital back-off: symbol peaks near -6 dBFS'
    value: '0.35'
  states: {}
- name: tx_taps
  id: variable
  parameters:
    comment: RRC interpolation straight to the radio rate, 16-symbol span
    value: '[tx_scale*t for t in firdes.root_raised_cosine(tx_interp, tx_interp, 1.0, 0.35, 16*tx_interp+1)]'
  states: {}
- name: adc_keep
  id: blocks_keep_m_in_n
  parameters:
    comment: raw ADC samples, 20 snapshots a second
    m: '8192'
    n: '300000'
    offset: '0'
    type: complex
  states: {}
- name: adc_pdu
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: adc_pkt
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '32768'
    packet_len: '8192'
    type: complex
  states: {}
- name: afc_ch0
  id: blocks_rotator_cc
  parameters:
    comment: carrier offset correction (node AFC)
    phase_inc: '0'
  states: {}
- name: afc_ch1
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
  states: {}
- name: afc_ch2
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
  states: {}
- name: afc_ch3
  id: blocks_rotator_cc
  parameters:
    phase_inc: '0'
  states: {}
- name: agc
  id: parameter
  parameters:
    comment: 1 = closed-loop RX gain / TX attenuation; 0 = fixed (/gain to move)
    label: Gain control (1/0)
    type: intx
    value: '1'
  states: {}
- name: agc_ch0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    comment: 'normalises the channel (symbol sync and Costas loop gains assume unit amplitude). Attack 1.0: a sample can never leave above 1.0, so a transmitter switching on cannot spike the symbol sync (agc2 did - it wedged)'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: 1e5
    reference: '1.0'
    type: complex
  states: {}
- name: agc_ch1
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: 1e5
    reference: '1.0'
    type: complex
  states: {}
- name: agc_ch2
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: 1e5
    reference: '1.0'
    type: complex
  states: {}
- name: agc_ch3
  id: analog_agc3_xx
  parameters:
    attack_rate: '1.0'
    decay_rate: '1e-4'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: 1e5
    reference: '1.0'
    type: complex
  states: {}
- name: arq_window
  id: parameter
  parameters:
    comment: Selective Repeat window, 1..64; 1 = stop-and-wait
    label: ARQ window (frames)
    type: intx
    value: '32'
  states: {}
- name: bits_to_vec_ch0
  id: blocks_stream_to_vector
  parameters:
    comment: 33 ms of bits per Python call; 4 s buffered, so a slow deframer never stalls the receiver
    minoutbuf: '128'
    num_items: '8192'
    type: byte
  states: {}
- name: bits_to_vec_ch1
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '128'
    num_items: '8192'
    type: byte
  states: {}
- name: bits_to_vec_ch2
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '128'
    num_items: '8192'
    type: byte
  states: {}
- name: bits_to_vec_ch3
  id: blocks_stream_to_vector
  parameters:
    minoutbuf: '128'
    num_items: '8192'
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    comment: drives ARQ timers, beacons and the node's housekeeping
    msg: pmt.intern("tick")
    period: '10'
  states: {}
- name: center_freq
  id: parameter
  parameters:
    comment: 'the same on every node: every channel sits above it'
    label: Centre frequency (Hz)
    type: eng_float
    value: 910.2e6
  states: {}
- name: ch_first
  id: parameter
  parameters:
    comment: 'r6.1 one-sided plan: channel k at ch_first + k*ch_spacing'
    label: Channel 0 offset (Hz)
    type: eng_float
    value: 450e3
  states: {}
- name: ch_spacing
  id: parameter
  parameters:
    comment: must divide radio_rate
    label: Channel spacing (Hz)
    type: eng_float
    value: 600e3
  states: {}
- name: chan_filter_ch0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ch_first+0*ch_spacing
    decim: decim
    samp_rate: radio_rate
    taps: ch_taps
    type: ccf
  states: {}
- name: chan_filter_ch1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ch_first+1*ch_spacing
    decim: decim
    samp_rate: radio_rate
    taps: ch_taps
    type: ccf
  states: {}
- name: chan_filter_ch2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ch_first+2*ch_spacing
    decim: decim
    samp_rate: radio_rate
    taps: ch_taps
    type: ccf
  states: {}
- name: chan_filter_ch3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ch_first+3*ch_spacing
    decim: decim
    samp_rate: radio_rate
    taps: ch_taps
    type: ccf
  states: {}
- name: channel
  id: parameter
  parameters:
    comment: '-1 = automatic, 0..3 fixed'
    label: TX channel
    type: intx
    value: '-1'
  states: {}
- name: const_keep_ch0
  id: blocks_keep_m_in_n
  parameters:
    m: '32'
    n: '512'
    offset: '0'
    type: complex
  states: {}
- name: const_keep_ch1
  id: blocks_keep_m_in_n
  parameters:
    m: '32'
    n: '512'
    offset: '0'
    type: complex
  states: {}
- name: const_keep_ch2
  id: blocks_keep_m_in_n
  parameters:
    m: '32'
    n: '512'
    offset: '0'
    type: complex
  states: {}
- name: const_keep_ch3
  id: blocks_keep_m_in_n
  parameters:
    m: '32'
    n: '512'
    offset: '0'
    type: complex
  states: {}
- name: const_sink_ch0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[3, 0, 1, 1]'
    label1: '"ch 0"'
    name: '"Channel 0"'
    size: '512'
    type: complex
    update_time: '0.20'
  states: {}
- name: const_sink_ch1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[3, 1, 1, 1]'
    label1: '"ch 1"'
    name: '"Channel 1"'
    size: '512'
    type: complex
    update_time: '0.20'
  states: {}
- name: const_sink_ch2
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[4, 0, 1, 1]'
    label1: '"ch 2"'
    name: '"Channel 2"'
    size: '512'
    type: complex
    update_time: '0.20'
  states: {}
- name: const_sink_ch3
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: '[4, 1, 1, 1]'
    label1: '"ch 3"'
    name: '"Channel 3"'
    size: '512'
    type: complex
    update_time: '0.20'
  states: {}
- name: costas_ch0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 3.14/100
  states: {}
- name: costas_ch1
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 3.14/100
  states: {}
- name: costas_ch2
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 3.14/100
  states: {}
- name: costas_ch3
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 3.14/100
  states: {}
- name: decoder_ch0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: decoder_ch1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: decoder_ch2
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: decoder_ch3
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: deframer_ch0
  id: epy_block
  parameters:
    _source_code: |
      """BPSK deframer for one receive channel (r6.1, embedded block).

      Input: hard-decision bits (0/1, one per byte) from the differential decoder,
      grouped by a Stream to Vector block into vectors of `batch` bits.
      Output, message port 'pdus': one PDU per link frame, metadata {'ch': k}; and
      once a second a PDU with an empty payload and metadata {'ch': k, 'stats':
      {...}}, which the node block uses as this channel's liveness check.

      The search is bpsk_phy.Deframer (next to the flowgraph). It replaces
      correlate_access_code_bb_ts -> repack_bits_bb -> tagged_stream_to_pdu, which
      on GNU Radio 3.10.12 could wait for 65535 bytes after one corrupted header
      and so stall the whole receiver ('repack_bits_bb is requesting more input
      data than we can provide'). This block never waits for data it does not
      have: it takes whatever whole vectors are there (Python is entered at most
      ~60 times a second per channel instead of once per few symbols, and the
      scheduler never calls into Python just to ask - a basic_block's forecast()
      would be a Python call on every scheduler pass), drops an implausible
      length at once, and keeps looking for access codes inside a frame it is
      still collecting, so one bad header costs at most that one frame.
      """

      import os
      import sys
      import time
      import traceback

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by path (GRC validates with exec() and no
          __file__, from whatever directory it was started in)."""
          import importlib.util
          if name in sys.modules:
              return sys.modules[name]
          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([p for p in sys.path if p])
          for root in roots:
              path = os.path.join(root, name + '.py')
              if os.path.isfile(path):
                  spec = importlib.util.spec_from_file_location(name, path)
                  mod = importlib.util.module_from_spec(spec)
                  sys.modules[name] = mod
                  try:
                      spec.loader.exec_module(mod)
                  except Exception:
                      sys.modules.pop(name, None)
                      raise
                  return mod
          return None


      try:
          _phy = _load('bpsk_phy')
          _err = '' if _phy is not None else 'bpsk_phy.py not found'
      except Exception as _e:          # noqa: BLE001 - reported at run time
          _phy, _err = None, repr(_e)


      class blk(gr.sync_block):
          """BPSK deframer: bits in, link frames out as PDUs."""

          def __init__(self, channel=0, max_len=600, batch=8192):
              gr.sync_block.__init__(self, name='BPSK Deframer',
                                     in_sig=[(np.uint8, int(batch))], out_sig=None)
              self.channel = int(channel)
              self.batch = int(batch)
              self._port = pmt.intern('pdus')
              self.message_port_register_out(self._port)
              self._core = (_phy.Deframer(max_len=int(max_len))
                            if _phy is not None else None)
              self._ch = pmt.from_long(self.channel)
              self._k_ch = pmt.intern('ch')
              self._k_stats = pmt.intern('stats')
              self._empty = pmt.init_u8vector(0, [])
              self._next = 0.0
              self._faults = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              frames = ()
              if n and self._core is not None:
                  try:
                      frames = self._core.feed(x.reshape(-1))
                  except Exception:                     # noqa: BLE001
                      self._faults += 1
                      if self._faults <= 3:
                          traceback.print_exc()
              for f in frames:
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  self.message_port_pub(self._port, pmt.cons(
                      meta, pmt.init_u8vector(len(f), list(f))))
              now = time.time()
              if now >= self._next:
                  self._next = now + 1.0
                  st = dict(self._core.stats) if self._core is not None else {}
                  st['faults'] = self._faults
                  if self._core is None:
                      st['error'] = _err
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  meta = pmt.dict_add(meta, self._k_stats, pmt.to_pmt(st))
                  self.message_port_pub(self._port, pmt.cons(meta, self._empty))
              return n
    batch: '8192'
    channel: '0'
    max_len: '600'
  states: {}
- name: deframer_ch1
  id: epy_block
  parameters:
    _source_code: |
      """BPSK deframer for one receive channel (r6.1, embedded block).

      Input: hard-decision bits (0/1, one per byte) from the differential decoder,
      grouped by a Stream to Vector block into vectors of `batch` bits.
      Output, message port 'pdus': one PDU per link frame, metadata {'ch': k}; and
      once a second a PDU with an empty payload and metadata {'ch': k, 'stats':
      {...}}, which the node block uses as this channel's liveness check.

      The search is bpsk_phy.Deframer (next to the flowgraph). It replaces
      correlate_access_code_bb_ts -> repack_bits_bb -> tagged_stream_to_pdu, which
      on GNU Radio 3.10.12 could wait for 65535 bytes after one corrupted header
      and so stall the whole receiver ('repack_bits_bb is requesting more input
      data than we can provide'). This block never waits for data it does not
      have: it takes whatever whole vectors are there (Python is entered at most
      ~60 times a second per channel instead of once per few symbols, and the
      scheduler never calls into Python just to ask - a basic_block's forecast()
      would be a Python call on every scheduler pass), drops an implausible
      length at once, and keeps looking for access codes inside a frame it is
      still collecting, so one bad header costs at most that one frame.
      """

      import os
      import sys
      import time
      import traceback

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by path (GRC validates with exec() and no
          __file__, from whatever directory it was started in)."""
          import importlib.util
          if name in sys.modules:
              return sys.modules[name]
          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([p for p in sys.path if p])
          for root in roots:
              path = os.path.join(root, name + '.py')
              if os.path.isfile(path):
                  spec = importlib.util.spec_from_file_location(name, path)
                  mod = importlib.util.module_from_spec(spec)
                  sys.modules[name] = mod
                  try:
                      spec.loader.exec_module(mod)
                  except Exception:
                      sys.modules.pop(name, None)
                      raise
                  return mod
          return None


      try:
          _phy = _load('bpsk_phy')
          _err = '' if _phy is not None else 'bpsk_phy.py not found'
      except Exception as _e:          # noqa: BLE001 - reported at run time
          _phy, _err = None, repr(_e)


      class blk(gr.sync_block):
          """BPSK deframer: bits in, link frames out as PDUs."""

          def __init__(self, channel=0, max_len=600, batch=8192):
              gr.sync_block.__init__(self, name='BPSK Deframer',
                                     in_sig=[(np.uint8, int(batch))], out_sig=None)
              self.channel = int(channel)
              self.batch = int(batch)
              self._port = pmt.intern('pdus')
              self.message_port_register_out(self._port)
              self._core = (_phy.Deframer(max_len=int(max_len))
                            if _phy is not None else None)
              self._ch = pmt.from_long(self.channel)
              self._k_ch = pmt.intern('ch')
              self._k_stats = pmt.intern('stats')
              self._empty = pmt.init_u8vector(0, [])
              self._next = 0.0
              self._faults = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              frames = ()
              if n and self._core is not None:
                  try:
                      frames = self._core.feed(x.reshape(-1))
                  except Exception:                     # noqa: BLE001
                      self._faults += 1
                      if self._faults <= 3:
                          traceback.print_exc()
              for f in frames:
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  self.message_port_pub(self._port, pmt.cons(
                      meta, pmt.init_u8vector(len(f), list(f))))
              now = time.time()
              if now >= self._next:
                  self._next = now + 1.0
                  st = dict(self._core.stats) if self._core is not None else {}
                  st['faults'] = self._faults
                  if self._core is None:
                      st['error'] = _err
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  meta = pmt.dict_add(meta, self._k_stats, pmt.to_pmt(st))
                  self.message_port_pub(self._port, pmt.cons(meta, self._empty))
              return n
    batch: '8192'
    channel: '1'
    max_len: '600'
  states: {}
- name: deframer_ch2
  id: epy_block
  parameters:
    _source_code: |
      """BPSK deframer for one receive channel (r6.1, embedded block).

      Input: hard-decision bits (0/1, one per byte) from the differential decoder,
      grouped by a Stream to Vector block into vectors of `batch` bits.
      Output, message port 'pdus': one PDU per link frame, metadata {'ch': k}; and
      once a second a PDU with an empty payload and metadata {'ch': k, 'stats':
      {...}}, which the node block uses as this channel's liveness check.

      The search is bpsk_phy.Deframer (next to the flowgraph). It replaces
      correlate_access_code_bb_ts -> repack_bits_bb -> tagged_stream_to_pdu, which
      on GNU Radio 3.10.12 could wait for 65535 bytes after one corrupted header
      and so stall the whole receiver ('repack_bits_bb is requesting more input
      data than we can provide'). This block never waits for data it does not
      have: it takes whatever whole vectors are there (Python is entered at most
      ~60 times a second per channel instead of once per few symbols, and the
      scheduler never calls into Python just to ask - a basic_block's forecast()
      would be a Python call on every scheduler pass), drops an implausible
      length at once, and keeps looking for access codes inside a frame it is
      still collecting, so one bad header costs at most that one frame.
      """

      import os
      import sys
      import time
      import traceback

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by path (GRC validates with exec() and no
          __file__, from whatever directory it was started in)."""
          import importlib.util
          if name in sys.modules:
              return sys.modules[name]
          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([p for p in sys.path if p])
          for root in roots:
              path = os.path.join(root, name + '.py')
              if os.path.isfile(path):
                  spec = importlib.util.spec_from_file_location(name, path)
                  mod = importlib.util.module_from_spec(spec)
                  sys.modules[name] = mod
                  try:
                      spec.loader.exec_module(mod)
                  except Exception:
                      sys.modules.pop(name, None)
                      raise
                  return mod
          return None


      try:
          _phy = _load('bpsk_phy')
          _err = '' if _phy is not None else 'bpsk_phy.py not found'
      except Exception as _e:          # noqa: BLE001 - reported at run time
          _phy, _err = None, repr(_e)


      class blk(gr.sync_block):
          """BPSK deframer: bits in, link frames out as PDUs."""

          def __init__(self, channel=0, max_len=600, batch=8192):
              gr.sync_block.__init__(self, name='BPSK Deframer',
                                     in_sig=[(np.uint8, int(batch))], out_sig=None)
              self.channel = int(channel)
              self.batch = int(batch)
              self._port = pmt.intern('pdus')
              self.message_port_register_out(self._port)
              self._core = (_phy.Deframer(max_len=int(max_len))
                            if _phy is not None else None)
              self._ch = pmt.from_long(self.channel)
              self._k_ch = pmt.intern('ch')
              self._k_stats = pmt.intern('stats')
              self._empty = pmt.init_u8vector(0, [])
              self._next = 0.0
              self._faults = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              frames = ()
              if n and self._core is not None:
                  try:
                      frames = self._core.feed(x.reshape(-1))
                  except Exception:                     # noqa: BLE001
                      self._faults += 1
                      if self._faults <= 3:
                          traceback.print_exc()
              for f in frames:
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  self.message_port_pub(self._port, pmt.cons(
                      meta, pmt.init_u8vector(len(f), list(f))))
              now = time.time()
              if now >= self._next:
                  self._next = now + 1.0
                  st = dict(self._core.stats) if self._core is not None else {}
                  st['faults'] = self._faults
                  if self._core is None:
                      st['error'] = _err
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  meta = pmt.dict_add(meta, self._k_stats, pmt.to_pmt(st))
                  self.message_port_pub(self._port, pmt.cons(meta, self._empty))
              return n
    batch: '8192'
    channel: '2'
    max_len: '600'
  states: {}
- name: deframer_ch3
  id: epy_block
  parameters:
    _source_code: |
      """BPSK deframer for one receive channel (r6.1, embedded block).

      Input: hard-decision bits (0/1, one per byte) from the differential decoder,
      grouped by a Stream to Vector block into vectors of `batch` bits.
      Output, message port 'pdus': one PDU per link frame, metadata {'ch': k}; and
      once a second a PDU with an empty payload and metadata {'ch': k, 'stats':
      {...}}, which the node block uses as this channel's liveness check.

      The search is bpsk_phy.Deframer (next to the flowgraph). It replaces
      correlate_access_code_bb_ts -> repack_bits_bb -> tagged_stream_to_pdu, which
      on GNU Radio 3.10.12 could wait for 65535 bytes after one corrupted header
      and so stall the whole receiver ('repack_bits_bb is requesting more input
      data than we can provide'). This block never waits for data it does not
      have: it takes whatever whole vectors are there (Python is entered at most
      ~60 times a second per channel instead of once per few symbols, and the
      scheduler never calls into Python just to ask - a basic_block's forecast()
      would be a Python call on every scheduler pass), drops an implausible
      length at once, and keeps looking for access codes inside a frame it is
      still collecting, so one bad header costs at most that one frame.
      """

      import os
      import sys
      import time
      import traceback

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by path (GRC validates with exec() and no
          __file__, from whatever directory it was started in)."""
          import importlib.util
          if name in sys.modules:
              return sys.modules[name]
          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([p for p in sys.path if p])
          for root in roots:
              path = os.path.join(root, name + '.py')
              if os.path.isfile(path):
                  spec = importlib.util.spec_from_file_location(name, path)
                  mod = importlib.util.module_from_spec(spec)
                  sys.modules[name] = mod
                  try:
                      spec.loader.exec_module(mod)
                  except Exception:
                      sys.modules.pop(name, None)
                      raise
                  return mod
          return None


      try:
          _phy = _load('bpsk_phy')
          _err = '' if _phy is not None else 'bpsk_phy.py not found'
      except Exception as _e:          # noqa: BLE001 - reported at run time
          _phy, _err = None, repr(_e)


      class blk(gr.sync_block):
          """BPSK deframer: bits in, link frames out as PDUs."""

          def __init__(self, channel=0, max_len=600, batch=8192):
              gr.sync_block.__init__(self, name='BPSK Deframer',
                                     in_sig=[(np.uint8, int(batch))], out_sig=None)
              self.channel = int(channel)
              self.batch = int(batch)
              self._port = pmt.intern('pdus')
              self.message_port_register_out(self._port)
              self._core = (_phy.Deframer(max_len=int(max_len))
                            if _phy is not None else None)
              self._ch = pmt.from_long(self.channel)
              self._k_ch = pmt.intern('ch')
              self._k_stats = pmt.intern('stats')
              self._empty = pmt.init_u8vector(0, [])
              self._next = 0.0
              self._faults = 0

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              frames = ()
              if n and self._core is not None:
                  try:
                      frames = self._core.feed(x.reshape(-1))
                  except Exception:                     # noqa: BLE001
                      self._faults += 1
                      if self._faults <= 3:
                          traceback.print_exc()
              for f in frames:
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  self.message_port_pub(self._port, pmt.cons(
                      meta, pmt.init_u8vector(len(f), list(f))))
              now = time.time()
              if now >= self._next:
                  self._next = now + 1.0
                  st = dict(self._core.stats) if self._core is not None else {}
                  st['faults'] = self._faults
                  if self._core is None:
                      st['error'] = _err
                  meta = pmt.dict_add(pmt.make_dict(), self._k_ch, self._ch)
                  meta = pmt.dict_add(meta, self._k_stats, pmt.to_pmt(st))
                  self.message_port_pub(self._port, pmt.cons(meta, self._empty))
              return n
    batch: '8192'
    channel: '3'
    max_len: '600'
  states: {}
- name: diff_decoder_ch0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: diff_decoder_ch1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: diff_decoder_ch2
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: diff_decoder_ch3
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: http_port
  id: parameter
  parameters:
    label: Chat UI port
    type: intx
    value: '8088'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: (int)(0.9*radio_rate)
    buffer_size: tx_buffer
    comment: one LO for TX and RX on every node
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: (int)(center_freq)
    samplerate: (int)(radio_rate)
    type: fc32
    uri: uri
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: (int)(0.9*radio_rate)
    bbdc: 'True'
    buffer_size: rx_buffer
    comment: 'manual gain: the node''s gain control sets it (IIO Attribute Sink) - an AGC in the chip would falsify the channel levels'
    filter_source: '''Auto'''
    frequency: (int)(center_freq)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: rx_gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: (int)(radio_rate)
    type: fc32
    uri: uri
  states: {}
- name: import_firdes
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: iq_keep_ch0
  id: blocks_keep_m_in_n
  parameters:
    m: '4096'
    n: '100000'
    offset: '0'
    type: complex
  states: {}
- name: iq_keep_ch1
  id: blocks_keep_m_in_n
  parameters:
    m: '4096'
    n: '100000'
    offset: '0'
    type: complex
  states: {}
- name: iq_keep_ch2
  id: blocks_keep_m_in_n
  parameters:
    m: '4096'
    n: '100000'
    offset: '0'
    type: complex
  states: {}
- name: iq_keep_ch3
  id: blocks_keep_m_in_n
  parameters:
    m: '4096'
    n: '100000'
    offset: '0'
    type: complex
  states: {}
- name: iq_pdu_ch0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: iq_pdu_ch1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: iq_pdu_ch2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: iq_pdu_ch3
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: iq_pkt_ch0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '16384'
    packet_len: '4096'
    type: complex
  states: {}
- name: iq_pkt_ch1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '16384'
    packet_len: '4096'
    type: complex
  states: {}
- name: iq_pkt_ch2
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '16384'
    packet_len: '4096'
    type: complex
  states: {}
- name: iq_pkt_ch3
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '16384'
    packet_len: '4096'
    type: complex
  states: {}
- name: keys_dir
  id: parameter
  parameters:
    label: Key directory
    type: str
    value: '''keys'''
  states: {}
- name: link_layer
  id: epy_block
  parameters:
    _source_code: |
      """GNU Radio shim for the BPSK network node (r6.1: FDMA mesh) and chat app.

      These files must sit in the same directory as the flowgraph:

          bpsk_link.py    framing, addressing, Selective Repeat ARQ, file segmentation
          bpsk_mac.py     channel and address self-assignment, beacons
          bpsk_secure.py  end-to-end encryption: Noise KK sessions, sealing
          bpsk_crypto.py  ChaCha20-Poly1305 / X25519 (pure Python or 'cryptography')
          bpsk_gain.py    closed-loop gain staging (RX gain, TX attenuation)
          bpsk_phy.py     deframer, transmit framer, AFC, measurements (numpy)
          bpsk_app.py     peers, conversations, receipts, HTTP + SSE server
          chat_ui.html    the browser front end

      Encryption is on by default. Keys live in <rx_dir>/<keys_dir>: this node's
      private key (bpsk_keys.py init) and the keys the operator has approved in the
      UI. With my_addr = 0 and peer_addr = 0 (the default) the node joins the mesh:
      it derives its address from its key, picks a free channel, and lists every
      node in range. Setting both gives the r5.4 two-node behaviour.

      This block owns none of that logic. It converts PMT to bytes, drives the
      state machine and turns its decisions into messages for the radio blocks.
      r6.1: it has NO stream inputs. Everything it measures arrives as short
      snapshots (Keep M in N -> Stream to Tagged Stream -> Tagged Stream to PDU,
      all C++), so nothing in the sample path ever waits for Python: the r6.0.1
      node block consumed four symbol streams and the raw receiver samples in
      general_work, was called thousands of times a second with a few samples,
      held the GIL, and when it fell behind the backlog reached the radio source.

      Ports in
          rx0..rx3    PDUs from each channel's deframer: link frames, plus a
                      once-a-second statistics PDU (empty payload) - the liveness
                      check of that receive chain
          meas0..3    512 recovered symbols (Costas output) of channel k, 10 a
                      second: SNR (EVM) and the constellation for the UI
          iq0..3      4096 samples of channel k before the matched filter, 10 a
                      second: channel level (dBFS) and the carrier offset (AFC)
          adc         8192 raw receiver samples, 20 a second: ADC peak, clipping,
                      spectrum; the input of the gain control
          txstat      the transmit framer's backlog, 20 a second
          rx_frame    decoded frames from a single-receiver flowgraph (r5)
          chat_in     the GNU Radio console edit box
          tick        Message Strobe, 10 ms
      Ports out
          tx_frame    link frames for the transmit framer (PDU)
          tx_en       {'enable': bool} for the transmit framer
          tx_ctl      {'inc': rad/sample} for the rotator that puts the
                      transmitter on its channel
          afc0..3     {'inc': rad/sample} for each receive channel's rotator
          rx_attr     {'hardwaregain': dB} for the IIO Attribute Sink (RX)
          tx_attr     {'hardwaregain': -dB} for the IIO Attribute Sink (TX)
          log         console lines

      The chat UI is served on 127.0.0.1:<http_port> and, like the stderr tap
      that counts gr-iio's 'O'/'U' marks and the telemetry files, starts on the
      first tick rather than in __init__: GRC instantiates this block every time
      it validates the flowgraph and must not be left holding a socket, a thread
      or a file.
      """

      import math
      import os
      import sys
      import threading
      import time
      import traceback
      from collections import deque

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by absolute path, never by module name.

          GRC validates this block by running exec() on this source in an empty
          namespace, so there is no __file__ and the working directory is wherever
          GRC was started. Loading the file directly makes both irrelevant, and
          swallowing every failure keeps a missing module from painting the block
          red in the editor - __init__ reports it on the console instead.
          """
          import importlib.util

          if name in sys.modules:
              return sys.modules[name]

          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([entry for entry in sys.path if entry])

          for root in roots:
              path = os.path.join(root, name + '.py')
              if not os.path.isfile(path):
                  continue
              spec = importlib.util.spec_from_file_location(name, path)
              module = importlib.util.module_from_spec(spec)
              sys.modules[name] = module
              try:
                  spec.loader.exec_module(module)
              except Exception:
                  sys.modules.pop(name, None)
                  raise
              return module
          return None


      _load_error = ''
      try:
          bpsk_link = _load('bpsk_link')
          for _dep in ('bpsk_crypto', 'bpsk_secure', 'bpsk_mac', 'bpsk_gain',
                       'bpsk_phy'):
              if bpsk_link is not None and _load(_dep) is None:
                  bpsk_link = None
          bpsk_app = _load('bpsk_app') if bpsk_link is not None else None
          bpsk_phy = sys.modules.get('bpsk_phy')
          if bpsk_app is None:
              _load_error = ('bpsk_link.py / bpsk_crypto.py / bpsk_secure.py / '
                             'bpsk_mac.py / bpsk_gain.py / bpsk_phy.py / '
                             'bpsk_app.py not found next to the flowgraph')
      except Exception as _err:            # noqa: BLE001 - reported, never raised
          bpsk_link = bpsk_app = bpsk_phy = None
          _load_error = repr(_err)


      def _to_text(msg):
          """Accept whatever the QT edit box emits and return a str."""
          try:
              if pmt.is_symbol(msg):
                  return pmt.symbol_to_string(msg)
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_u8vector(val):
                      return bytes(bytearray(pmt.u8vector_elements(val))).decode(
                          'utf-8', 'replace')
                  if pmt.is_symbol(val):
                      return pmt.symbol_to_string(val)
          except Exception:
              pass
          return None


      def _to_bytes(msg):
          """Extract the u8vector of a PDU as bytes."""
          try:
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_u8vector(val):
                      return bytes(bytearray(pmt.u8vector_elements(val)))
          except Exception:
              pass
          return None


      def _to_complex(msg):
          """The c32vector of a PDU as a numpy array (or None)."""
          try:
              if pmt.is_pair(msg):
                  val = pmt.cdr(msg)
                  if pmt.is_c32vector(val):
                      return np.asarray(pmt.c32vector_elements(val),
                                        dtype=np.complex64)
          except Exception:
              pass
          return None


      def _meta(msg):
          try:
              if pmt.is_pair(msg) and pmt.is_dict(pmt.car(msg)):
                  return pmt.to_python(pmt.car(msg)) or {}
          except Exception:
              pass
          return {}


      NUM_CHANNELS = 4          # fixed by the flowgraph: four receive chains
      OUT_RATE_SPS = 4          # samples per symbol after the channel filters
      STALL = 3.0               # seconds without data that make a chain 'stalled'
      # snapshot taps in the flowgraph (keep m in n): one every n items of
      TAP_EVERY = {'meas': 25000,     # symbols (after the Costas loop)
                   'iq': 100000,      # channel samples (after the AFC rotator)
                   'adc': 300000}     # radio samples
      CPU_EVERY = 2.0           # seconds between per-thread CPU readings
      VIEW_EVERY = 1.0          # seconds between constellation/spectrum pushes


      class StderrTap(object):
          """Counts gr-iio's overflow 'O' / underflow 'U' marks.

          gr-iio writes them with fprintf(stderr, ...) from its own overflow and
          underflow threads, at most one per second per direction, so the only
          place to see them is file descriptor 2. A pipe is put there; a thread
          copies everything to the real stderr unchanged and counts the marks
          (bpsk_phy.count_ou). The pipe is enlarged to 1 MiB so writers never
          block even if this thread is briefly kept from the GIL, and any failure
          puts the original stderr back.
          """

          def __init__(self):
              self.overflows = 0
              self.underflows = 0
              self.active = False
              self.error = None
              self._orig = None
              self._r = None
              self._thread = None
              self._state = None

          def start(self):
              if bpsk_phy is None or self.active:
                  return
              try:
                  sys.stderr.flush()
                  self._orig = os.dup(2)
                  r, w = os.pipe()
                  try:
                      import fcntl
                      fcntl.fcntl(w, getattr(fcntl, 'F_SETPIPE_SZ', 1031), 1 << 20)
                  except Exception:                     # noqa: BLE001
                      pass
                  os.dup2(w, 2)
                  os.close(w)
                  self._r = r
                  self.active = True
                  self._thread = threading.Thread(target=self._run, daemon=True,
                                                  name='bpsk-stderr-tap')
                  self._thread.start()
              except Exception as exc:                  # noqa: BLE001
                  self.error = repr(exc)
                  self._restore()

          def _run(self):
              try:
                  while True:
                      data = os.read(self._r, 65536)
                      if not data:
                          break
                      os.write(self._orig, data)
                      o, u, self._state = bpsk_phy.count_ou(
                          data.decode('latin-1'), self._state)
                      self.overflows += o
                      self.underflows += u
              except Exception as exc:                  # noqa: BLE001
                  self.error = repr(exc)
              finally:
                  self._restore()

          def _restore(self):
              if self._orig is not None:
                  try:
                      os.dup2(self._orig, 2)
                  except OSError:
                      pass
              self.active = False

          def stop(self):
              if not self.active:
                  return
              self._restore()               # writers now go to the real stderr
              try:
                  os.close(self._r)         # the reader thread sees EOF/EBADF
              except OSError:
                  pass
              if self._thread is not None:
                  self._thread.join(timeout=0.5)
              try:
                  os.close(self._orig)
              except OSError:
                  pass
              self._orig = None


      def _thread_cpu():
          """{tid: (name, cpu seconds)} of this process's threads (Linux)."""
          out = {}
          tick = float(os.sysconf('SC_CLK_TCK'))
          base = '/proc/self/task'
          try:
              tids = os.listdir(base)
          except OSError:
              return out
          for tid in tids:
              try:
                  with open('%s/%s/stat' % (base, tid)) as fh:
                      st = fh.read()
                  with open('%s/%s/comm' % (base, tid)) as fh:
                      name = fh.read().strip()
              except OSError:
                  continue
              f = st[st.rfind(')') + 2:].split()
              out[tid] = (name, (int(f[11]) + int(f[12])) / tick)
          return out


      class blk(gr.basic_block):
          """BPSK network node: MAC, ARQ link layer, encryption, chat UI."""

          def __init__(self, my_addr=0, peer_addr=0, ack_timeout=0.5, max_retries=5,
                       frag_size=256, queue_ahead=0.03, sym_rate=250000.0,
                       overhead=140, rx_dir='.', nickname='', http_port=8088,
                       open_ui=True, center_freq=0.0, security=True,
                       keys_dir='keys', window=32, channel=-1, ch_spacing=600e3,
                       ch_first=450e3, radio_rate=6e6, rx_gain=30, tx_atten=50,
                       agc=True, telemetry=True, plan_file='', count_ou=True):
              gr.basic_block.__init__(self, name='BPSK Chat Node', in_sig=None,
                                      out_sig=None)
              self.http_port = int(http_port)
              self.open_ui = bool(open_ui)
              self.radio_rate = float(radio_rate)
              self.ch_rate = OUT_RATE_SPS * float(sym_rate)
              # a chain is stalled after STALL s without data, or four snapshot
              # intervals when those are longer (slowed-down bench)
              self.stall = max(STALL, 4.0 * max(
                  TAP_EVERY['meas'] / float(sym_rate),
                  TAP_EVERY['iq'] / self.ch_rate,
                  TAP_EVERY['adc'] / self.radio_rate))
              self.app = None
              self.link = None
              if bpsk_app is None:
                  print('[chat] ERROR: could not load the protocol modules: %s'
                        % _load_error, flush=True)
              else:
                  root = os.path.abspath(rx_dir or '.')
                  store = os.path.join(root, 'chat_files')
                  chan = int(channel)
                  self.app = bpsk_app.ChatApp(
                      my_addr=int(my_addr) or None, peer_addr=int(peer_addr) or None,
                      nick=nickname or None, store_dir=store,
                      ack_timeout=ack_timeout, max_retries=max_retries,
                      frag_size=frag_size, queue_ahead=queue_ahead,
                      sym_rate=sym_rate, overhead=overhead,
                      tx_freq=center_freq, rx_freq=center_freq,
                      security=bool(security),
                      keys_dir=os.path.join(root, keys_dir or 'keys'),
                      window=int(window),
                      channel=chan if 0 <= chan < NUM_CHANNELS else None,
                      num_channels=NUM_CHANNELS, ch_spacing=float(ch_spacing),
                      ch_first=float(ch_first), filler='keepalive',
                      gain=dict(rx_gain=rx_gain, tx_atten=tx_atten,
                                auto=bool(agc)),
                      telemetry_dir=(os.path.join(root, 'telemetry')
                                     if telemetry else None),
                      plan_file=(os.path.join(root, plan_file)
                                 if plan_file else None))
                  self.link = self.app.link

              # GNU Radio's Python gateway looks a handler up BY NAME on the block
              # (set_msg_handler passes handler.__name__ to C++), so every port
              # needs a real method - a lambda or partial aborts the flowgraph.
              handlers = [('chat_in', self._on_chat), ('rx_frame', self._on_rx),
                          ('tick', self._on_tick), ('adc', self._on_adc),
                          ('txstat', self._on_txstat)]
              for k in range(NUM_CHANNELS):
                  handlers += [('rx%d' % k, getattr(self, '_on_rx%d' % k)),
                               ('meas%d' % k, getattr(self, '_on_meas%d' % k)),
                               ('iq%d' % k, getattr(self, '_on_iq%d' % k))]
              for port, fn in handlers:
                  self.message_port_register_in(pmt.intern(port))
                  self.set_msg_handler(pmt.intern(port), fn)
              outs = ['tx_frame', 'tx_en', 'tx_ctl', 'rx_attr', 'tx_attr', 'log'] \
                  + ['afc%d' % k for k in range(NUM_CHANNELS)]
              for port in outs:
                  self.message_port_register_out(pmt.intern(port))

              self._lock = threading.RLock()
              self._last_strobe = 0.0
              self._watchdog = None
              self._server = None
              self._opened = False
              # Set by stop(). Everything that can touch a message port or acquire a
              # resource checks it first: after stop() the runtime is tearing the
              # block down, and publishing to a port from a Python thread at that
              # point is a call into freed C++.
              self._halt = threading.Event()
              self._faults = 0
              # Interned once; _dispatch runs up to 100 times a second.
              self._port_log = pmt.intern('log')
              self._port_tx = pmt.intern('tx_frame')
              self._port_en = pmt.intern('tx_en')
              self._port_ctl = pmt.intern('tx_ctl')
              self._port_rxa = pmt.intern('rx_attr')
              self._port_txa = pmt.intern('tx_attr')
              self._port_afc = [pmt.intern('afc%d' % k) for k in range(NUM_CHANNELS)]
              self._k_inc = pmt.intern('inc')
              self._k_en = pmt.intern('enable')
              self._k_gain = pmt.intern('hardwaregain')
              # Physical-layer state (r6.1).
              self._afc = ([bpsk_phy.Afc(self.ch_rate) for _ in range(NUM_CHANNELS)]
                           if bpsk_phy is not None else [])
              self._lvl = [None] * NUM_CHANNELS          # (t, dBFS) per channel
              self._lvl_push = 0.0
              self._seen = {'meas': [0.0] * NUM_CHANNELS, 'iq': [0.0] * NUM_CHANNELS,
                            'dfr': [0.0] * NUM_CHANNELS, 'adc': 0.0}
              self._dfr = [None] * NUM_CHANNELS
              self._dfr_bits = [None] * NUM_CHANNELS
              self._fault = None
              self._fault_told = -1e9
              self._started = None
              self._disp = deque()                       # (serial, airtime) sent
              self._serial = 0
              self._txq = {}
              self._tap = StderrTap() if count_ou else None
              self._cpu_prev = None
              self._cpu_next = 0.0
              self._view = {'const': [None] * NUM_CHANNELS, 'spectrum': None}
              self._view_next = 0.0
              if self.link is not None:
                  self._say(self.app.banner())
                  if self.app.plan_note:
                      self._say(self.app.plan_note)

          # ------------------------------------------------------------ plumbing
          def _say(self, text):
              for line in str(text).splitlines():
                  print('[link] %s' % line, flush=True)
              if self._halt.is_set():
                  return
              self.message_port_pub(self._port_log, pmt.string_to_symbol(str(text)))

          def _inc(self, offset_hz, rate):
              return pmt.dict_add(pmt.make_dict(), self._k_inc,
                                  pmt.from_double(2.0 * math.pi * offset_hz / rate))

          def _dispatch(self, actions):
              if self._halt.is_set():
                  return
              for kind, value in actions:
                  if kind == 'tx':
                      vec = pmt.init_u8vector(len(value), list(bytearray(value)))
                      self.message_port_pub(self._port_tx, pmt.cons(pmt.PMT_NIL, vec))
                      self._serial += 1
                      self._disp.append((self._serial,
                                         self.link.radio.airtime(len(value))))
                      while len(self._disp) > 4096:
                          self._disp.popleft()
                  elif kind == 'chan':
                      # Retune the transmitter: the rotator after the modulator.
                      # Receive is untouched (all channels).
                      self.message_port_pub(self._port_ctl, self._inc(
                          float(self.app.offset(value)), self.radio_rate))
                  elif kind == 'txen':
                      self.message_port_pub(self._port_en, pmt.dict_add(
                          pmt.make_dict(), self._k_en, pmt.from_bool(bool(value))))
                  elif kind == 'gain':
                      # IIO Attribute Sinks; bpsk_gain keeps the values in range,
                      # which matters: attr_sink throws on a refused write.
                      v = int(value['value'])
                      port = self._port_rxa if value['what'] == 'rx' \
                          else self._port_txa
                      text = str(v if value['what'] == 'rx' else -v)
                      self.message_port_pub(port, pmt.dict_add(
                          pmt.make_dict(), self._k_gain, pmt.intern(text)))
                  elif kind == 'log':
                      self._say(value)

          def _fault_tb(self, where):
              self._faults += 1
              n = self._faults
              if n <= 5 or n % 1000 == 0:
                  print('[chat] INTERNAL ERROR #%d in %s - that input was discarded, '
                        'the node keeps running:' % (n, where), flush=True)
                  traceback.print_exc()
                  sys.stdout.flush()
                  sys.stderr.flush()
                  if n == 5:
                      print('[chat] further tracebacks are printed every 1000th '
                            'fault only', flush=True)
                  try:
                      self._say('internal error in %s (#%d) - traceback on the '
                                'terminal' % (where, n))
                  except Exception:
                      pass

          # -------------------------------------------------------------- startup
          def _ensure_running(self):
              """Start the UI server, the fallback timer and the stderr tap on first
              traffic. Deferred out of __init__ so that GRC, which instantiates this
              block every time it validates the flowgraph, never binds the port,
              spawns a thread or redirects a file descriptor.
              """
              if self.app is None or self._halt.is_set():
                  return
              if self._started is None:
                  self._started = time.time()
                  if self._tap is not None:
                      self._tap.start()
                  # gr-iio's Pluto source template never applies its RF bandwidth
                  # parameter (3.10), so the receiver's analog filter is whatever
                  # the device had. Set it for the channel plan: 0.9 x the rate.
                  bw = int(max(2e5, min(5.6e7, 0.9 * self.radio_rate)))
                  self.message_port_pub(self._port_rxa, pmt.dict_add(
                      pmt.make_dict(), pmt.intern('rf_bandwidth'),
                      pmt.intern(str(bw))))
              if self._server is None:
                  try:
                      self._server, _ = bpsk_app.serve(self.app, self.http_port)
                      url = 'http://127.0.0.1:%d/' % self.http_port
                      self._say('chat UI ready at %s  (files in %s)'
                                % (url, self.app.store_dir))
                      if self.open_ui and not self._opened:
                          self._opened = True
                          threading.Thread(target=self._open_browser, args=(url,),
                                           daemon=True).start()
                  except OSError as exc:
                      self._server = False        # do not retry every 10 ms
                      self._say('could not start the chat UI on port %d: %s'
                                % (self.http_port, exc))
              if self._watchdog is None:
                  self._watchdog = threading.Thread(target=self._watchdog_loop,
                                                    daemon=True)
                  self._watchdog.start()

          @staticmethod
          def _open_browser(url):
              import webbrowser
              time.sleep(0.7)
              try:
                  webbrowser.open(url)
              except Exception:
                  pass

          def stop(self):
              """Stop the watchdog and release the port, in that order.

              Order matters. The watchdog drives on_tick and publishes the frames it
              produces; left running it keeps calling message_port_pub while the
              runtime destroys the block. Because stop() also freezes _last_strobe,
              the watchdog ENGAGES within 250 ms of teardown and then publishes at
              100 Hz, so this is the steady state during shutdown, not a rare race.
              """
              self._halt.set()
              watchdog, self._watchdog = self._watchdog, None
              if watchdog is not None and watchdog.is_alive():
                  watchdog.join(timeout=1.0)
              server, self._server = self._server, None
              if server:
                  bpsk_app.shutdown(server)
              if self._tap is not None:
                  self._tap.stop()
              if self.app is not None:
                  self.app.close()
              return True

          # -------------------------------------------------------- message ports
          def _watchdog_loop(self):
              """Drive on_tick if the Message Strobe stops delivering.

              Every ARQ timer and the beacons hang off the tick port. If that port
              goes quiet the link silently wedges: nothing retransmits and the queue
              never drains. This takes over after 250 ms of silence and stands down
              if the strobe returns.
              """
              engaged = False
              while not self._halt.is_set():
                  if self._halt.wait(0.01):
                      return                      # stop() asked us to leave
                  try:
                      with self._lock:
                          if self.app is None or self._halt.is_set():
                              continue
                          if (time.time() - self._last_strobe) < 0.25:
                              if engaged:
                                  engaged = False
                                  self._say('message strobe recovered, watchdog '
                                            'standing down')
                              continue
                          if not engaged:
                              engaged = True
                              self._say('WARNING: no tick from the Message Strobe '
                                        'block - driving ARQ timers and beacons '
                                        'from the fallback thread instead')
                          self._dispatch(self.app.on_tick(time.time()))
                  except Exception:
                      self._fault_tb('watchdog')

          def _on_chat(self, msg):
              if self.app is None or self._halt.is_set():
                  return
              text = _to_text(msg)
              if text is None:
                  return
              try:
                  with self._lock:
                      self._ensure_running()
                      self._dispatch(self.app.on_console(text, time.time()))
              except Exception:
                  self._fault_tb('chat_in')

          def _on_rx(self, msg, channel=None):
              if self.app is None or self._halt.is_set():
                  return
              raw = _to_bytes(msg)
              if raw is None:
                  return
              try:
                  with self._lock:
                      self._ensure_running()
                      now = time.time()
                      if not raw:
                          meta = _meta(msg)
                          if channel is not None and 'stats' in meta:
                              self._on_deframer_stats(channel, meta['stats'], now)
                          return
                      self._dispatch(self.app.on_rx(raw, now, channel=channel))
              except Exception:
                  self._fault_tb('rx_frame' if channel is None else 'rx%d' % channel)

          def _on_rx0(self, msg):
              self._on_rx(msg, 0)

          def _on_rx1(self, msg):
              self._on_rx(msg, 1)

          def _on_rx2(self, msg):
              self._on_rx(msg, 2)

          def _on_rx3(self, msg):
              self._on_rx(msg, 3)

          def _on_meas0(self, msg):
              self._on_meas(msg, 0)

          def _on_meas1(self, msg):
              self._on_meas(msg, 1)

          def _on_meas2(self, msg):
              self._on_meas(msg, 2)

          def _on_meas3(self, msg):
              self._on_meas(msg, 3)

          def _on_iq0(self, msg):
              self._on_iq(msg, 0)

          def _on_iq1(self, msg):
              self._on_iq(msg, 1)

          def _on_iq2(self, msg):
              self._on_iq(msg, 2)

          def _on_iq3(self, msg):
              self._on_iq(msg, 3)

          def _on_tick(self, msg):
              if self.app is None or self._halt.is_set():
                  return
              try:
                  with self._lock:
                      now = time.time()
                      self._last_strobe = now
                      self._ensure_running()
                      self._push_levels(now)
                      self._dispatch(self.app.on_tick(now))
                      self._housekeeping(now)
              except Exception:
                  self._fault_tb('tick')

          # ------------------------------------------------- physical layer (r6.1)
          def _on_meas(self, msg, k):
              """Recovered symbols of channel k: SNR from the EVM (decisions on
              the real axis, which is what a locked differential BPSK receiver
              produces after the Costas loop), and the constellation for the UI."""
              if self.app is None or self._halt.is_set() or bpsk_phy is None:
                  return
              try:
                  x = _to_complex(msg)
                  if x is None or not len(x):
                      return
                  now = time.time()
                  self._seen['meas'][k] = now
                  snr, evm = bpsk_phy.evm_snr(x)
                  with self._lock:
                      if snr is None:
                          self.app.set_radio_metrics(snr_db=None, evm=None,
                                                     locked=False, channel=k)
                      else:
                          self.app.set_radio_metrics(
                              snr_db=round(snr, 2), evm=round(100.0 * evm, 2),
                              locked=bool(snr > 5.0), channel=k)
                  if now >= self._view_next - 0.5:
                      pts = x[:96]
                      self._view['const'][k] = [[round(float(z.real), 2),
                                                 round(float(z.imag), 2)]
                                                for z in pts]
              except Exception:
                  self._fault_tb('meas%d' % k)

          def _on_iq(self, msg, k):
              """Channel k before the matched filter: its in-band level relative
              to ADC full scale (the channel filters have unity gain; the level is
              taken after a matched filter, so it is what the decoder sees) and
              the AFC."""
              if self.app is None or self._halt.is_set() or bpsk_phy is None:
                  return
              try:
                  x = _to_complex(msg)
                  if x is None or not len(x):
                      return
                  now = time.time()
                  self._seen['iq'][k] = now
                  lvl = bpsk_phy.inband_level_db(x)
                  self._lvl[k] = (now, round(lvl, 1))
                  with self._lock:
                      self.app.set_radio_metrics(level_db=round(lvl, 1), channel=k)
                  afc = self._afc[k]
                  inc = afc.update(now, x)
                  if inc is not None and not self._halt.is_set():
                      self.message_port_pub(self._port_afc[k], pmt.dict_add(
                          pmt.make_dict(), self._k_inc, pmt.from_double(inc)))
              except Exception:
                  self._fault_tb('iq%d' % k)

          def _on_adc(self, msg):
              """Raw receiver samples: ADC peak and clipping (the gain control's
              input), and a spectrum for the UI."""
              if self.app is None or self._halt.is_set() or bpsk_phy is None:
                  return
              try:
                  x = _to_complex(msg)
                  if x is None or not len(x):
                      return
                  now = time.time()
                  self._seen['adc'] = now
                  st = bpsk_phy.adc_stats(x)
                  with self._lock:
                      self.app.set_adc(peak_dbfs=round(st['peak_dbfs'], 1),
                                       rms_dbfs=round(st['rms_dbfs'], 1),
                                       clip=st['clip'], t=now)
                  if now >= self._view_next - 0.5 and self._view['spectrum'] is None:
                      self._view['spectrum'] = bpsk_phy.spectrum_db(x, 128)
              except Exception:
                  self._fault_tb('adc')

          def _on_txstat(self, msg):
              """The transmit framer's report: correct the airtime model."""
              if self.app is None or self._halt.is_set():
                  return
              try:
                  st = pmt.to_python(msg) if pmt.is_dict(msg) else None
                  if not st:
                      return
                  received = (st.get('accepted', 0) + st.get('dropped', 0)
                              + st.get('rejected', 0))
                  while self._disp and self._disp[0][0] <= received:
                      self._disp.popleft()
                  pending = sum(a for _, a in self._disp)
                  now = time.time()
                  with self._lock:
                      if st.get('enabled') and st.get('backlog') is not None:
                          self.link.radio.observe(
                              now, float(st['t']) + float(st['backlog']) + pending)
                      self._txq = {'backlog': st.get('backlog'),
                                   'dropped': st.get('dropped', 0),
                                   'flushed': st.get('flushed', 0),
                                   'enabled': bool(st.get('enabled')),
                                   'sent': st.get('sent', 0),
                                   'fill_bits': st.get('fill_bits', 0),
                                   'model_error': self.link.radio.model_error,
                                   'error': st.get('error')}
              except Exception:
                  self._fault_tb('txstat')

          def _on_deframer_stats(self, k, stats, now):
              if not isinstance(stats, dict):
                  return
              bits = stats.get('bits')
              if bits is not None and bits != self._dfr_bits[k]:
                  self._seen['dfr'][k] = now
              self._dfr_bits[k] = bits
              self._dfr[k] = stats

          def _push_levels(self, now):
              """One level per channel, all from the last 0.3 s, ten times a
              second: the MAC's energy detection compares them with each other."""
              if now - self._lvl_push < 0.1:
                  return
              self._lvl_push = now
              lv = [(v[1] if v is not None and now - v[0] < 0.3 else None)
                    for v in self._lvl]
              if any(x is not None for x in lv):
                  self.app.set_channel_levels(lv, now)

          def _housekeeping(self, now):
              """Liveness, counters, CPU and UI snapshots (all cheap; every tick)."""
              started = self._started or now
              warm = now - started > self.stall + 2.0
              adc_age = now - self._seen['adc'] if self._seen['adc'] else None
              chans = []
              for k in range(NUM_CHANNELS):
                  last = min(self._seen['meas'][k], self._seen['dfr'][k])
                  chans.append(bool(last) and now - last < self.stall)
              fault = None
              if warm and (adc_age is None or adc_age > self.stall):
                  fault = ('receiver stalled: no samples from the radio for more '
                           'than %.0f s - check the E200 link (USB/Ethernet) and '
                           'the console' % self.stall)
              elif warm and not all(chans):
                  dead = [k for k in range(NUM_CHANNELS) if not chans[k]]
                  fault = ('receive chain of channel%s %s stalled (no data for '
                           'more than %.0f s)%s'
                           % ('s' if len(dead) > 1 else '',
                              ', '.join(str(k) for k in dead), self.stall,
                              '; the other channels are unaffected'
                              if len(dead) < NUM_CHANNELS else ''))
              if fault != self._fault:
                  self._fault = fault
                  if fault:
                      self._fault_told = now
                      self._say('FAULT: ' + fault)
                      self.app._system(fault, 'error')
                  elif warm:
                      self._say('receive chains running again')
              elif fault and now - self._fault_told > 30.0:
                  self._fault_told = now
                  self._say('FAULT (continuing): ' + fault)
              self.app.set_phy('live', {'channels': chans, 'fault': fault,
                                        'adc_age': adc_age})
              tap = self._tap
              self.app.set_phy('ou', {'overflows': tap.overflows if tap else None,
                                      'underflows': tap.underflows if tap else None,
                                      'tap': bool(tap and tap.active),
                                      'error': tap.error if tap else None})
              self.app.set_phy('afc', [{'cfo': round(a.cfo, 1),
                                        'residual': (round(a.residual, 1)
                                                     if a.residual is not None
                                                     else None),
                                        'ratio': round(a.ratio, 1),
                                        'updates': a.updates} for a in self._afc])
              self.app.set_phy('deframer', list(self._dfr))
              self.app.set_phy('txq', dict(self._txq))
              if now >= self._cpu_next:
                  self._cpu_next = now + CPU_EVERY
                  self._sample_cpu(now)
              if now >= self._view_next:
                  self._view_next = now + VIEW_EVERY
                  self.app.publish_view(dict(self._view))
                  self._view = {'const': [None] * NUM_CHANNELS, 'spectrum': None}

          def _sample_cpu(self, now):
              """CPU per GNU Radio thread (threads carry their block's name)."""
              snap = _thread_cpu()
              proc = sum(os.times()[:2])
              prev, self._cpu_prev = self._cpu_prev, (now, snap, proc)
              if prev is None:
                  return
              dt = max(1e-3, now - prev[0])
              agg = {}
              for tid, (name, c) in snap.items():
                  old = prev[1].get(tid)
                  if old is None:
                      continue
                  key = name.rstrip('0123456789') or name
                  agg[key] = agg.get(key, 0.0) + (c - old[1]) / dt
              top = sorted(agg.items(), key=lambda kv: -kv[1])[:12]
              self.app.set_phy('cpu', {'process': round((proc - prev[2]) / dt, 2),
                                       'top': [[n, round(c, 3)] for n, c in top
                                               if c >= 0.005]})
    ack_timeout: ack_timeout
    agc: agc
    center_freq: center_freq
    ch_first: ch_first
    ch_spacing: ch_spacing
    channel: channel
    comment: MAC + link layer + encryption + gain control + chat UI
    count_ou: 'True'
    frag_size: frag_size
    http_port: http_port
    keys_dir: keys_dir
    max_retries: max_retries
    my_addr: my_addr
    nickname: nickname
    open_ui: 'True'
    overhead: preamble_size+postamble_size+12
    peer_addr: peer_addr
    plan_file: plan_file
    queue_ahead: queue_ahead
    radio_rate: radio_rate
    rx_dir: '"."'
    rx_gain: rx_gain
    security: security
    sym_rate: sym_rate
    telemetry: telemetry
    tx_atten: tx_atten
    window: arq_window
  states: {}
- name: meas_keep_ch0
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '25000'
    offset: '0'
    type: complex
  states: {}
- name: meas_keep_ch1
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '25000'
    offset: '0'
    type: complex
  states: {}
- name: meas_keep_ch2
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '25000'
    offset: '0'
    type: complex
  states: {}
- name: meas_keep_ch3
  id: blocks_keep_m_in_n
  parameters:
    m: '512'
    n: '25000'
    offset: '0'
    type: complex
  states: {}
- name: meas_pdu_ch0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: meas_pdu_ch1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: meas_pdu_ch2
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: meas_pdu_ch3
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: meas_pkt_ch0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '2048'
    packet_len: '512'
    type: complex
  states: {}
- name: meas_pkt_ch1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '2048'
    packet_len: '512'
    type: complex
  states: {}
- name: meas_pkt_ch2
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '2048'
    packet_len: '512'
    type: complex
  states: {}
- name: meas_pkt_ch3
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    minoutbuf: '2048'
    packet_len: '512'
    type: complex
  states: {}
- name: my_addr
  id: parameter
  parameters:
    comment: 0 = derived from the key
    label: My address
    type: intx
    value: '0'
  states: {}
- name: nickname
  id: parameter
  parameters:
    label: Chat nickname
    type: str
    value: ''''''
  states: {}
- name: peer_addr
  id: parameter
  parameters:
    comment: '0 = mesh; with my_addr: static two-node mode'
    label: Peer address
    type: intx
    value: '0'
  states: {}
- name: plan_file
  id: parameter
  parameters:
    comment: 'optional JSON {"channels": {"<fingerprint|nickname>": k}}'
    label: Static channel plan file
    type: str
    value: ''''''
  states: {}
- name: postamble_size
  id: parameter
  parameters:
    label: Postamble (bytes)
    type: intx
    value: '64'
  states: {}
- name: preamble_size
  id: parameter
  parameters:
    label: Preamble (bytes)
    type: intx
    value: '64'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: fallback console - the chat UI is served on http_port
    gui_hint: '[0, 0, 1, 2]'
    is_pair: 'False'
    key: '""'
    label: '"Console  (the chat lives in the browser; /stats, /gain, /help here)"'
    type: string
    value: '""'
  states: {}
- name: radio_rate
  id: parameter
  parameters:
    comment: 'r6.1: 6 MS/s, one-sided channel plan'
    label: Radio sample rate
    type: eng_float
    value: 6e6
  states: {}
- name: rrc_ch0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: rrc_ch1
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: rrc_ch2
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: rrc_ch3
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: rx_attr
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    comment: RX gain (hardwaregain) and RF bandwidth from the node
    device: '"ad9361-phy"'
    output: 'False'
    uri: uri
  states: {}
- name: rx_buffer
  id: parameter
  parameters:
    label: Pluto RX buffer (samples)
    type: intx
    value: '65536'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    comment: gain control moves it from here (agc=1)
    label: RX gain at start (dB)
    type: intx
    value: '30'
  states: {}
- name: rx_spec_keep
  id: blocks_keep_m_in_n
  parameters:
    m: '1024'
    n: '61440'
    offset: '0'
    type: complex
  states: {}
- name: rx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    comment: '1024 samples in 61440 (C++, no copy of the rest): the GUI never holds the radio back'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[1, 0, 2, 2]'
    label1: '""'
    name: '"RX spectrum"'
    type: complex
    update_time: '0.20'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: security
  id: parameter
  parameters:
    label: Encryption (1/0)
    type: intx
    value: '1'
  states: {}
- name: symbol_sync_ch0
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.01'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: symbol_sync_ch1
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.01'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: symbol_sync_ch2
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.01'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: symbol_sync_ch3
  id: digital_symbol_sync_xx
  parameters:
    constellation: constel.base()
    damping: '1.0'
    loop_bw: '0.02'
    max_dev: '0.01'
    nfilters: '32'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '0.1'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: telemetry
  id: parameter
  parameters:
    comment: one row per second in telemetry/
    label: Telemetry CSV (1/0)
    type: intx
    value: '1'
  states: {}
- name: tx_atten
  id: parameter
  parameters:
    comment: gain control moves it from here (agc=1)
    label: TX attenuation at start (dB)
    type: intx
    value: '50'
  states: {}
- name: tx_attr
  id: iio_attr_sink
  parameters:
    attr_type: '0'
    channel: '"voltage0"'
    comment: TX attenuation (hardwaregain = -dB) from the node
    device: '"ad9361-phy"'
    output: 'True'
    uri: uri
  states: {}
- name: tx_buffer
  id: parameter
  parameters:
    label: Pluto TX buffer (samples)
    type: intx
    value: '49152'
  states: {}
- name: tx_framer
  id: epy_block
  parameters:
    _source_code: |
      """BPSK transmit framer (r6.1, embedded block).

      Message port 'frames' in: link frames (PDUs) from the node block. Port 'ctl'
      in: {'enable': bool}. Stream out: BPSK symbols, one per symbol period, to the
      interpolating RRC filter. Port 'status' out, every 50 ms: the transmit
      backlog, so the node's airtime model tracks the real queue.

      The radio pulls symbols at exactly its own rate, so this block's queue is
      the whole transmit backlog. While enabled, gaps between frames are filled
      with a PRBS-15 pattern (no access code can appear in it) so the carrier is
      continuous without the link layer making ~200 IDLE frames a second; while
      disabled (the MAC listening or checking its channel) it sends zeros, which
      keeps the DAC fed - no 'U' - and the channel silent. Switching off is
      immediate: the frame on air and any still queued are discarded (the link
      layer's ARQ resends what mattered). The framing and modulation
      are bpsk_phy.TxFramer, identical on air to r6.0's tagged_stream_mux +
      generic_mod(differential BPSK).
      """

      import os
      import sys
      import time
      import traceback

      import numpy as np
      import pmt
      from gnuradio import gr


      def _load(name):
          """Load a sibling module by path (see the deframer block)."""
          import importlib.util
          if name in sys.modules:
              return sys.modules[name]
          roots = []
          try:
              roots.append(os.path.dirname(os.path.abspath(__file__)))
          except NameError:
              pass
          roots.append(os.getcwd())
          roots.extend([p for p in sys.path if p])
          for root in roots:
              path = os.path.join(root, name + '.py')
              if os.path.isfile(path):
                  spec = importlib.util.spec_from_file_location(name, path)
                  mod = importlib.util.module_from_spec(spec)
                  sys.modules[name] = mod
                  try:
                      spec.loader.exec_module(mod)
                  except Exception:
                      sys.modules.pop(name, None)
                      raise
                  return mod
          return None


      try:
          _phy = _load('bpsk_phy')
          _err = '' if _phy is not None else 'bpsk_phy.py not found'
      except Exception as _e:          # noqa: BLE001 - reported at run time
          _phy, _err = None, repr(_e)


      class blk(gr.sync_block):
          """BPSK TX framer: link frames in, continuous symbols out."""

          def __init__(self, preamble_size=64, postamble_size=64,
                       sym_rate=250000.0, max_backlog=0.5, batch=2560):
              gr.sync_block.__init__(self, name='BPSK TX Framer', in_sig=None,
                                     out_sig=[np.complex64])
              self.set_output_multiple(max(64, int(batch)))
              self._in = pmt.intern('frames')
              self._ctl = pmt.intern('ctl')
              self._out = pmt.intern('status')
              self.message_port_register_in(self._in)
              self.message_port_register_in(self._ctl)
              self.message_port_register_out(self._out)
              # GNU Radio finds a Python handler again BY NAME: real methods only.
              self.set_msg_handler(self._in, self._on_frame)
              self.set_msg_handler(self._ctl, self._on_ctl)
              self._core = (_phy.TxFramer(preamble_size, postamble_size, sym_rate,
                                          max_backlog) if _phy is not None else None)
              self._enabled = False
              self._flushed = 0
              self._next = 0.0
              self._faults = 0
              self._sent_syms = 0

          def _on_frame(self, msg):
              try:
                  if self._core is None or not pmt.is_pair(msg):
                      return
                  vec = pmt.cdr(msg)
                  if pmt.is_u8vector(vec):
                      self._core.push(bytes(pmt.u8vector_elements(vec)))
              except Exception:                         # noqa: BLE001
                  self._fault()

          def _on_ctl(self, msg):
              try:
                  if pmt.is_dict(msg):
                      val = pmt.dict_ref(msg, pmt.intern('enable'), pmt.PMT_NIL)
                      if pmt.is_bool(val):
                          on = pmt.to_bool(val)
                          if not on and self._core is not None:
                              c = self._core
                              self._flushed += len(c.queue) + (c.cur is not None)
                              c.queue.clear()
                              c.queued_bits = 0
                              c.cur, c.pos = None, 0
                          self._enabled = on
              except Exception:                         # noqa: BLE001
                  self._fault()

          def _fault(self):
              self._faults += 1
              if self._faults <= 3:
                  traceback.print_exc()

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              core = self._core
              if core is None or not self._enabled:
                  out[:] = 0
              else:
                  try:
                      out[:] = core.next_symbols(n)
                  except Exception:                     # noqa: BLE001
                      self._fault()
                      out[:] = 0
              self._sent_syms += n
              now = time.time()
              if now >= self._next:
                  self._next = now + 0.05
                  st = {'t': now, 'enabled': self._enabled,
                        'symbols': self._sent_syms, 'flushed': self._flushed,
                        'faults': self._faults}
                  if core is not None:
                      st.update(core.stats)
                      st['backlog'] = core.backlog()
                  else:
                      st['error'] = _err
                  self.message_port_pub(self._out, pmt.to_pmt(st))
              return n
    batch: '2560'
    comment: frames + PRBS filler, pulled by the radio
    max_backlog: '0.5'
    maxoutbuf: '7680'
    minoutbuf: '7680'
    postamble_size: postamble_size
    preamble_size: preamble_size
    sym_rate: sym_rate
  states: {}
- name: tx_interp_filter
  id: interp_fir_filter_xxx
  parameters:
    interp: tx_interp
    taps: tx_taps
    type: ccf
  states: {}
- name: tx_shift
  id: blocks_rotator_cc
  parameters:
    comment: puts the transmitter on its channel (node tx_ctl)
    phase_inc: '0'
  states: {}
- name: tx_spec_keep
  id: blocks_keep_m_in_n
  parameters:
    m: '1024'
    n: '61440'
    offset: '0'
    type: complex
  states: {}
- name: tx_spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: radio_rate
    comment: 'own transmitter: adjacent-channel leakage (ACLR) is visible here'
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[5, 0, 2, 2]'
    label1: '""'
    name: '"TX spectrum"'
    type: complex
    update_time: '0.20'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: uri
  id: parameter
  parameters:
    label: Pluto URI
    type: str
    value: '''ip:192.168.1.10'''
  states: {}

connections:
- [adc_keep, '0', adc_pkt, '0']
- [adc_pdu, pdus, link_layer, adc]
- [adc_pkt, '0', adc_pdu, '0']
- [afc_ch0, '0', agc_ch0, '0']
- [afc_ch0, '0', iq_keep_ch0, '0']
- [afc_ch1, '0', agc_ch1, '0']
- [afc_ch1, '0', iq_keep_ch1, '0']
- [afc_ch2, '0', agc_ch2, '0']
- [afc_ch2, '0', iq_keep_ch2, '0']
- [afc_ch3, '0', agc_ch3, '0']
- [afc_ch3, '0', iq_keep_ch3, '0']
- [agc_ch0, '0', rrc_ch0, '0']
- [agc_ch1, '0', rrc_ch1, '0']
- [agc_ch2, '0', rrc_ch2, '0']
- [agc_ch3, '0', rrc_ch3, '0']
- [bits_to_vec_ch0, '0', deframer_ch0, '0']
- [bits_to_vec_ch1, '0', deframer_ch1, '0']
- [bits_to_vec_ch2, '0', deframer_ch2, '0']
- [bits_to_vec_ch3, '0', deframer_ch3, '0']
- [blocks_message_strobe_0, strobe, link_layer, tick]
- [chan_filter_ch0, '0', afc_ch0, '0']
- [chan_filter_ch1, '0', afc_ch1, '0']
- [chan_filter_ch2, '0', afc_ch2, '0']
- [chan_filter_ch3, '0', afc_ch3, '0']
- [const_keep_ch0, '0', const_sink_ch0, '0']
- [const_keep_ch1, '0', const_sink_ch1, '0']
- [const_keep_ch2, '0', const_sink_ch2, '0']
- [const_keep_ch3, '0', const_sink_ch3, '0']
- [costas_ch0, '0', const_keep_ch0, '0']
- [costas_ch0, '0', decoder_ch0, '0']
- [costas_ch0, '0', meas_keep_ch0, '0']
- [costas_ch1, '0', const_keep_ch1, '0']
- [costas_ch1, '0', decoder_ch1, '0']
- [costas_ch1, '0', meas_keep_ch1, '0']
- [costas_ch2, '0', const_keep_ch2, '0']
- [costas_ch2, '0', decoder_ch2, '0']
- [costas_ch2, '0', meas_keep_ch2, '0']
- [costas_ch3, '0', const_keep_ch3, '0']
- [costas_ch3, '0', decoder_ch3, '0']
- [costas_ch3, '0', meas_keep_ch3, '0']
- [decoder_ch0, '0', diff_decoder_ch0, '0']
- [decoder_ch1, '0', diff_decoder_ch1, '0']
- [decoder_ch2, '0', diff_decoder_ch2, '0']
- [decoder_ch3, '0', diff_decoder_ch3, '0']
- [deframer_ch0, pdus, link_layer, rx0]
- [deframer_ch1, pdus, link_layer, rx1]
- [deframer_ch2, pdus, link_layer, rx2]
- [deframer_ch3, pdus, link_layer, rx3]
- [diff_decoder_ch0, '0', bits_to_vec_ch0, '0']
- [diff_decoder_ch1, '0', bits_to_vec_ch1, '0']
- [diff_decoder_ch2, '0', bits_to_vec_ch2, '0']
- [diff_decoder_ch3, '0', bits_to_vec_ch3, '0']
- [iio_pluto_source_0, '0', adc_keep, '0']
- [iio_pluto_source_0, '0', chan_filter_ch0, '0']
- [iio_pluto_source_0, '0', chan_filter_ch1, '0']
- [iio_pluto_source_0, '0', chan_filter_ch2, '0']
- [iio_pluto_source_0, '0', chan_filter_ch3, '0']
- [iio_pluto_source_0, '0', rx_spec_keep, '0']
- [iq_keep_ch0, '0', iq_pkt_ch0, '0']
- [iq_keep_ch1, '0', iq_pkt_ch1, '0']
- [iq_keep_ch2, '0', iq_pkt_ch2, '0']
- [iq_keep_ch3, '0', iq_pkt_ch3, '0']
- [iq_pdu_ch0, pdus, link_layer, iq0]
- [iq_pdu_ch1, pdus, link_layer, iq1]
- [iq_pdu_ch2, pdus, link_layer, iq2]
- [iq_pdu_ch3, pdus, link_layer, iq3]
- [iq_pkt_ch0, '0', iq_pdu_ch0, '0']
- [iq_pkt_ch1, '0', iq_pdu_ch1, '0']
- [iq_pkt_ch2, '0', iq_pdu_ch2, '0']
- [iq_pkt_ch3, '0', iq_pdu_ch3, '0']
- [link_layer, afc0, afc_ch0, cmd]
- [link_layer, afc1, afc_ch1, cmd]
- [link_layer, afc2, afc_ch2, cmd]
- [link_layer, afc3, afc_ch3, cmd]
- [link_layer, rx_attr, rx_attr, attr]
- [link_layer, tx_attr, tx_attr, attr]
- [link_layer, tx_ctl, tx_shift, cmd]
- [link_layer, tx_en, tx_framer, ctl]
- [link_layer, tx_frame, tx_framer, frames]
- [meas_keep_ch0, '0', meas_pkt_ch0, '0']
- [meas_keep_ch1, '0', meas_pkt_ch1, '0']
- [meas_keep_ch2, '0', meas_pkt_ch2, '0']
- [meas_keep_ch3, '0', meas_pkt_ch3, '0']
- [meas_pdu_ch0, pdus, link_layer, meas0]
- [meas_pdu_ch1, pdus, link_layer, meas1]
- [meas_pdu_ch2, pdus, link_layer, meas2]
- [meas_pdu_ch3, pdus, link_layer, meas3]
- [meas_pkt_ch0, '0', meas_pdu_ch0, '0']
- [meas_pkt_ch1, '0', meas_pdu_ch1, '0']
- [meas_pkt_ch2, '0', meas_pdu_ch2, '0']
- [meas_pkt_ch3, '0', meas_pdu_ch3, '0']
- [qtgui_edit_box_msg_0, msg, link_layer, chat_in]
- [rrc_ch0, '0', symbol_sync_ch0, '0']
- [rrc_ch1, '0', symbol_sync_ch1, '0']
- [rrc_ch2, '0', symbol_sync_ch2, '0']
- [rrc_ch3, '0', symbol_sync_ch3, '0']
- [rx_spec_keep, '0', rx_spectrum, '0']
- [symbol_sync_ch0, '0', costas_ch0, '0']
- [symbol_sync_ch1, '0', costas_ch1, '0']
- [symbol_sync_ch2, '0', costas_ch2, '0']
- [symbol_sync_ch3, '0', costas_ch3, '0']
- [tx_framer, '0', tx_interp_filter, '0']
- [tx_framer, status, link_layer, txstat]
- [tx_interp_filter, '0', tx_shift, '0']
- [tx_interp_filter, '0', tx_spec_keep, '0']
- [tx_shift, '0', iio_pluto_sink_0, '0']
- [tx_spec_keep, '0', tx_spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
